* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* CDL Netlist:                                              *
*                                                           *
* Cell Name  : aska_top_16ele_v2_TOP                        *
* Netlisted  : Wed Oct 16 15:18:27 2024                     *
* PVS Version: 23.11-s036 Wed Jan 17 18:11:41 PST 2024      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
*.LDD
*.DEVTMPLT 0 MP(pmb) pmb pdiff(D) p1trm(G) pdiff(S) dnwtrm(B)
*.DEVTMPLT 1 LDDN(nedia) nedia2_d dnwtrm(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 2 LDDP(ped) ped12_d pwitrm(D) p1trm(G) pdiff(S) bulk(B)
*.DEVTMPLT 3 MN(ne3) nem ndiff(D) p1trm(G) ndiff(S) bulk(B)
*.DEVTMPLT 4 MP(pe3) pem pdiff(D) p1trm(G) pdiff(S) nwtrm(B)
*.DEVTMPLT 5 MN(ne3i) nemi ndiff(D) p1trm(G) ndiff(S) pwitrm(B)
*.DEVTMPLT 6 MP(pe3i) pemi pdiff(D) p1trm(G) pdiff(S) dnwtrm(B)
*.DEVTMPLT 7 NE3I_6() nemi_6 ndiff(D) p1trm(G) ndiff(S) pwitrm(B) dnwtrm(NW) bulk(SB)
*.DEVTMPLT 8 MOSVC3() mosvcm p1trm(G) nwtrm(NW) bulk(SB)
*.DEVTMPLT 9 Q(qpvc3) qpvmc bulk(C) nwtrm(B) pdiff(E)
*.DEVTMPLT 10 R(rdp_io) rdp_io_g pdiff(POS) pdiff(NEG) dnwtrm(SUB)
*.DEVTMPLT 11 R(s_res) s_res bulk(POS) bulk(NEG)
*.DEVTMPLT 12 D(p_dnw) p_dnw bulk(POS) nwtrm(NEG)
*.DEVTMPLT 13 D(dhpw) d_dhpw pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 14 D(ddnw) d_ddnw bulk(POS) dnwtrm(NEG)
*.DEVTMPLT 15 D(p_ddnw) p_ddnw bulk(POS) dnwtrm(NEG)
*.DEVTMPLT 16 D(ddnwmv) d_ddnwmv bulk(POS) dnwtrm(NEG)
*.DEVTMPLT 17 D(p_ddnwmv) p_ddnwmv bulk(POS) dnwtrm(NEG)
*.DEVTMPLT 18 D(dipdnwmv) d_dipwmv pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 19 D(p_dipdnwmv) p_dipwmv pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 20 D(p_dwhn) p_dwhn bulk(POS) hnw(NEG)
*.DEVTMPLT 21 D(dpdd_scr) dpdd_scr pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 22 D(dnpdd_scr) dnpddscr pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 23 D(dpp20) dpp20 pwitrm(POS) dnwtrm(NEG)
*.DEVTMPLT 24 D(dphnw) d_dphnw1 pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 25 D(dpdnw) d_dpdnw pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 26 D(dsba) d_dsba d_dsdf(POS) hnw(NEG) bulk(SUB)
*.DEVTMPLT 27 R(rdn3) rdnm_gi ndiff(POS) ndiff(NEG) pwitrm(SUB)
*.DEVTMPLT 28 R(rdp3) rdpm pdiff(POS) pdiff(NEG) nwtrm(SUB)
*.DEVTMPLT 29 R(rdp3) rdpmi pdiff(POS) pdiff(NEG) dnwtrm(SUB)
*.DEVTMPLT 30 R(rdp3) rdpm_gi pdiff(POS) pdiff(NEG) dnwtrm(SUB)
*.DEVTMPLT 31 D(dn3) d_dnmi1 pwitrm(POS) ndiff(NEG)
*.DEVTMPLT 32 D(dp3) d_dpm pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 33 D(dp3) d_dpmi1 pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 34 D(p_dp3) p_dpm pdiff(POS) nwtrm(NEG)
*.DEVTMPLT 35 D(p_dp3) p_dpmi1 pdiff(POS) dnwtrm(NEG)
*.DEVTMPLT 36 D(p_dnw3) p_dnwm bulk(POS) nwtrm(NEG)
*.DEVTMPLT 37 R(rpp1k1_3) rpp1k1_s p1trm(POS) p1trm(NEG) bulk(SUB)
*.DEVTMPLT 38 R(rpp1k1_3) rpp1k1_n p1trm(POS) p1trm(NEG) nwtrm(SUB)
*.DEVTMPLT 39 R(rnp1) rnp1_2 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 40 R(rpp1) rpp1_2 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 41 R(rpp1s) rpp1s_2 p1trm(POS) p1trm(NEG)
*.DEVTMPLT 42 C(csf4a) d_csf4a m1atrm(POS) m1btrm(NEG)
*.DEVTMPLT 43 C(cmm5t) cmim capm(POS) m4trm(NEG)

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NE3I_6                                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NE3I_6 D G S B NW SB
.ends NE3I_6

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: LDDP                                            *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt LDDP D G S B
.ends LDDP

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MOSVC3                                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MOSVC3 G NW SB
.ends MOSVC3

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: LDDN                                            *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt LDDN D G S B
.ends LDDN

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_CDNS_729084393830                         *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_CDNS_729084393830 1 2 3 4
** N=4 EP=4 FDC=12
X0 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=-680 $Y=-4850 $dt=1
X1 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=11220 $Y=-4850 $dt=1
X2 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=23120 $Y=-4850 $dt=1
X3 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=35020 $Y=-4850 $dt=1
X4 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=46920 $Y=-4850 $dt=1
X5 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=58820 $Y=-4850 $dt=1
X6 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=70720 $Y=-4850 $dt=1
X7 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=82620 $Y=-4850 $dt=1
X8 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=94520 $Y=-4850 $dt=1
X9 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=106420 $Y=-4850 $dt=1
X10 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=118320 $Y=-4850 $dt=1
X11 2 3 4 1 LDDN w=5e-05 l=1.25e-06 adio=6.71697e-10 pdio=3.30958e-05 extlay=1 $[nedia] $X=130220 $Y=-4850 $dt=1
.ends nedia_CDNS_729084393830

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ped_CDNS_729084393831                           *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ped_CDNS_729084393831 1 2 3 4
** N=4 EP=4 FDC=12
X0 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=-2270 $Y=0 $dt=2
X1 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=6530 $Y=0 $dt=2
X2 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=15330 $Y=0 $dt=2
X3 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=24130 $Y=0 $dt=2
X4 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=32930 $Y=0 $dt=2
X5 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=41730 $Y=0 $dt=2
X6 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=50530 $Y=0 $dt=2
X7 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=59330 $Y=0 $dt=2
X8 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=68130 $Y=0 $dt=2
X9 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=76930 $Y=0 $dt=2
X10 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=85730 $Y=0 $dt=2
X11 2 4 3 1 LDDP w=5e-05 l=9.4e-07 ad=2.19714e-10 pd=8.94366e-05 adio=4.2498e-10 pdio=2.57015e-05 extlay=1 $[ped] $X=94530 $Y=0 $dt=2
.ends ped_CDNS_729084393831

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_CDNS_729084393832                         *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_CDNS_729084393832 1 2 3 4
** N=4 EP=4 FDC=1
X0 2 4 3 1 LDDN w=2e-05 l=1.25e-06 adio=7.56916e-10 pdio=0.00010535 extlay=1 $[nedia] $X=-680 $Y=-4850 $dt=1
.ends nedia_CDNS_729084393832

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_729084393833                           *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_729084393833 1 2 3 4
** N=4 EP=4 FDC=1
M0 3 2 1 4 ne3 L=3.5e-07 W=2.2e-07 AD=1.984e-13 AS=1.984e-13 PD=1.88e-06 PS=1.88e-06 $X=0 $Y=0 $dt=3
.ends ne3_CDNS_729084393833

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_729084393835                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_729084393835 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.0002029 W=2e-06 $[rpp1k1_3] $SUB=3 $X=-2220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_729084393835

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: dsba_CDNS_729084393836                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt dsba_CDNS_729084393836 1 2 3
** N=623 EP=3 FDC=21
D0 1 2 p_dwhn AREA=6.69221e-10 PJ=0.00022132 perimeter=0.00022132 $X=-3330 $Y=-3970 $dt=20
D1 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=1390 $Y=1050 $dt=26
D2 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=5350 $Y=1050 $dt=26
D3 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=9310 $Y=1050 $dt=26
D4 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=13270 $Y=1050 $dt=26
D5 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=17230 $Y=1050 $dt=26
D6 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=21190 $Y=1050 $dt=26
D7 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=25150 $Y=1050 $dt=26
D8 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=29110 $Y=1050 $dt=26
D9 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=33070 $Y=1050 $dt=26
D10 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=37030 $Y=1050 $dt=26
D11 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=40990 $Y=1050 $dt=26
D12 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=44950 $Y=1050 $dt=26
D13 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=48910 $Y=1050 $dt=26
D14 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=52870 $Y=1050 $dt=26
D15 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=56830 $Y=1050 $dt=26
D16 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=60790 $Y=1050 $dt=26
D17 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=64750 $Y=1050 $dt=26
D18 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=68710 $Y=1050 $dt=26
D19 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=72670 $Y=1050 $dt=26
D20 3 2 dsba AREA=1.41e-11 PJ=3.188e-05 perimeter=3.188e-05 $SUB=1 $X=76630 $Y=1050 $dt=26
.ends dsba_CDNS_729084393836

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: dpp20_CDNS_729084393837                         *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt dpp20_CDNS_729084393837 1 2 3
** N=3 EP=3 FDC=2
D0 1 2 p_ddnw AREA=1.12107e-09 PJ=0.00016136 perimeter=0.00016136 $X=-6420 $Y=-6420 $dt=15
D1 3 2 dpp20 AREA=2.5e-10 PJ=0.00011 perimeter=0.00011 $X=0 $Y=0 $dt=23
.ends dpp20_CDNS_729084393837

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_729084393838                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_729084393838 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.0002537 W=2e-06 $[rpp1k1_3] $SUB=3 $X=-2220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_729084393838

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_729084393839                           *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_729084393839 1 2 3
*.DEVICECLIMB
** N=4 EP=3 FDC=1
M0 3 2 1 1 pe3 L=3e-07 W=4.4e-07 AD=2.112e-13 AS=2.112e-13 PD=1.84e-06 PS=1.84e-06 $X=0 $Y=0 $dt=4
.ends pe3_CDNS_729084393839

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: hvswitch8                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt hvswitch8 1 2 3 4 5 6 7 8 9
** N=15 EP=9 FDC=433
X0 1 3 10 9 nedia_CDNS_729084393830 $T=238930 110910 0 0 $X=222710 $Y=91520
X1 1 3 2 11 ped_CDNS_729084393831 $T=370960 203710 0 180 $X=259210 $Y=163760
X2 1 10 4 12 nedia_CDNS_729084393832 $T=31955 142520 0 0 $X=15735 $Y=123130
X3 1 13 4 14 nedia_CDNS_729084393832 $T=71980 142520 0 0 $X=55760 $Y=123130
X4 7 6 12 1 ne3_CDNS_729084393833 $T=20540 111655 0 0 $X=19700 $Y=111235
X5 7 8 15 1 ne3_CDNS_729084393833 $T=23885 111645 0 0 $X=23045 $Y=111225
X6 7 15 14 1 ne3_CDNS_729084393833 $T=27205 111645 0 0 $X=26365 $Y=111225
X7 10 4 1 rpp1k1_3_CDNS_729084393835 $T=22985 175685 0 0 $X=19825 $Y=175465
X8 2 11 1 rpp1k1_3_CDNS_729084393835 $T=63010 196610 0 0 $X=59850 $Y=196390
X9 1 10 4 dsba_CDNS_729084393836 $T=119535 121415 0 0 $X=111425 $Y=112665
X10 1 2 3 dpp20_CDNS_729084393837 $T=163730 200845 0 90 $X=102650 $Y=189765
X11 1 2 3 dpp20_CDNS_729084393837 $T=241095 201100 0 90 $X=180015 $Y=190020
X12 2 10 1 rpp1k1_3_CDNS_729084393838 $T=16595 197030 0 0 $X=13435 $Y=196810
X13 11 13 1 rpp1k1_3_CDNS_729084393838 $T=56660 175685 0 0 $X=53500 $Y=175465
X14 5 6 12 pe3_CDNS_729084393839 $T=20540 115965 1 0 $X=19030 $Y=114495
X15 5 8 15 pe3_CDNS_729084393839 $T=23860 115965 1 0 $X=22350 $Y=114495
X16 5 15 14 pe3_CDNS_729084393839 $T=27180 115965 1 0 $X=25670 $Y=114495
D0 1 5 p_dnw AREA=3.39001e-11 PJ=3.421e-05 perimeter=3.421e-05 $X=17815 $Y=113330 $dt=12
D1 1 5 p_dnw3 AREA=2.49e-11 PJ=0 perimeter=0 $X=19030 $Y=114495 $dt=36
C2 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=41445 $dt=42
C3 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=47485 $dt=42
C4 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=53525 $dt=42
C5 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=59565 $dt=42
C6 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=65605 $dt=42
C7 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=71645 $dt=42
C8 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=77685 $dt=42
C9 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=83725 $dt=42
C10 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=89765 $dt=42
C11 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=11155 $Y=95805 $dt=42
C12 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=12135 $Y=10115 $dt=42
C13 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=12135 $Y=21815 $dt=42
C14 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=18175 $Y=10115 $dt=42
C15 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=18175 $Y=21815 $dt=42
C16 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=41445 $dt=42
C17 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=47485 $dt=42
C18 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=53525 $dt=42
C19 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=59565 $dt=42
C20 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=65605 $dt=42
C21 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=71645 $dt=42
C22 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=77685 $dt=42
C23 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=83725 $dt=42
C24 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=89765 $dt=42
C25 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=22855 $Y=95805 $dt=42
C26 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=24215 $Y=10115 $dt=42
C27 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=24215 $Y=21815 $dt=42
C28 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=30255 $Y=10115 $dt=42
C29 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=30255 $Y=21815 $dt=42
C30 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=41445 $dt=42
C31 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=47485 $dt=42
C32 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=53525 $dt=42
C33 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=59565 $dt=42
C34 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=65605 $dt=42
C35 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=71645 $dt=42
C36 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=77685 $dt=42
C37 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=83725 $dt=42
C38 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=89765 $dt=42
C39 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=34555 $Y=95805 $dt=42
C40 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=36295 $Y=10115 $dt=42
C41 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=36295 $Y=21815 $dt=42
C42 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=42335 $Y=10115 $dt=42
C43 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=42335 $Y=21815 $dt=42
C44 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=41445 $dt=42
C45 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=47485 $dt=42
C46 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=53525 $dt=42
C47 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=59565 $dt=42
C48 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=65605 $dt=42
C49 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=71645 $dt=42
C50 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=77685 $dt=42
C51 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=83725 $dt=42
C52 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=89765 $dt=42
C53 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=46255 $Y=95805 $dt=42
C54 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=48375 $Y=10115 $dt=42
C55 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=48375 $Y=21815 $dt=42
C56 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=54415 $Y=10115 $dt=42
C57 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=54415 $Y=21815 $dt=42
C58 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=41445 $dt=42
C59 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=47485 $dt=42
C60 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=53525 $dt=42
C61 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=59565 $dt=42
C62 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=65605 $dt=42
C63 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=71645 $dt=42
C64 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=77685 $dt=42
C65 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=83725 $dt=42
C66 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=89765 $dt=42
C67 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=57955 $Y=95805 $dt=42
C68 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=60455 $Y=10115 $dt=42
C69 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=60455 $Y=21815 $dt=42
C70 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=66495 $Y=10115 $dt=42
C71 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=66495 $Y=21815 $dt=42
C72 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=41445 $dt=42
C73 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=47485 $dt=42
C74 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=53525 $dt=42
C75 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=59565 $dt=42
C76 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=65605 $dt=42
C77 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=71645 $dt=42
C78 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=77685 $dt=42
C79 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=83725 $dt=42
C80 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=89765 $dt=42
C81 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=69655 $Y=95805 $dt=42
C82 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=72535 $Y=10115 $dt=42
C83 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=72535 $Y=21815 $dt=42
C84 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=78575 $Y=10115 $dt=42
C85 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=78575 $Y=21815 $dt=42
C86 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=41445 $dt=42
C87 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=47485 $dt=42
C88 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=53525 $dt=42
C89 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=59565 $dt=42
C90 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=65605 $dt=42
C91 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=71645 $dt=42
C92 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=77685 $dt=42
C93 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=83725 $dt=42
C94 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=89765 $dt=42
C95 4 10 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=81355 $Y=95805 $dt=42
C96 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=84615 $Y=10115 $dt=42
C97 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=84615 $Y=21815 $dt=42
C98 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=90655 $Y=10115 $dt=42
C99 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=90655 $Y=21815 $dt=42
C100 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=96695 $Y=10115 $dt=42
C101 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=96695 $Y=21815 $dt=42
C102 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=96990 $Y=37085 $dt=42
C103 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=96990 $Y=48785 $dt=42
C104 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=96990 $Y=60485 $dt=42
C105 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=102735 $Y=10115 $dt=42
C106 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=102735 $Y=21815 $dt=42
C107 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=103030 $Y=37085 $dt=42
C108 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=103030 $Y=48785 $dt=42
C109 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=103030 $Y=60485 $dt=42
C110 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=108775 $Y=10115 $dt=42
C111 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=108775 $Y=21815 $dt=42
C112 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=109070 $Y=37085 $dt=42
C113 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=109070 $Y=48785 $dt=42
C114 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=109070 $Y=60485 $dt=42
C115 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=114815 $Y=10115 $dt=42
C116 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=114815 $Y=21815 $dt=42
C117 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=115110 $Y=37085 $dt=42
C118 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=115110 $Y=48785 $dt=42
C119 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=115110 $Y=60485 $dt=42
C120 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=118085 $Y=79030 $dt=42
C121 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=118085 $Y=90730 $dt=42
C122 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=120855 $Y=10115 $dt=42
C123 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=120855 $Y=21815 $dt=42
C124 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=121150 $Y=37085 $dt=42
C125 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=121150 $Y=48785 $dt=42
C126 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=121150 $Y=60485 $dt=42
C127 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=124125 $Y=79030 $dt=42
C128 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=124125 $Y=90730 $dt=42
C129 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=126895 $Y=10115 $dt=42
C130 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=126895 $Y=21815 $dt=42
C131 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=127190 $Y=37085 $dt=42
C132 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=127190 $Y=48785 $dt=42
C133 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=127190 $Y=60485 $dt=42
C134 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=130165 $Y=79030 $dt=42
C135 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=130165 $Y=90730 $dt=42
C136 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=132935 $Y=10115 $dt=42
C137 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=132935 $Y=21815 $dt=42
C138 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=133230 $Y=37085 $dt=42
C139 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=133230 $Y=48785 $dt=42
C140 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=133230 $Y=60485 $dt=42
C141 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=136205 $Y=79030 $dt=42
C142 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=136205 $Y=90730 $dt=42
C143 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=138975 $Y=10115 $dt=42
C144 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=138975 $Y=21815 $dt=42
C145 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=139270 $Y=37085 $dt=42
C146 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=139270 $Y=48785 $dt=42
C147 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=139270 $Y=60485 $dt=42
C148 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=142245 $Y=79030 $dt=42
C149 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=142245 $Y=90730 $dt=42
C150 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=145015 $Y=10115 $dt=42
C151 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=145015 $Y=21815 $dt=42
C152 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=145310 $Y=37085 $dt=42
C153 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=145310 $Y=48785 $dt=42
C154 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=145310 $Y=60485 $dt=42
C155 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=148285 $Y=79030 $dt=42
C156 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=148285 $Y=90730 $dt=42
C157 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=151055 $Y=10115 $dt=42
C158 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=151055 $Y=21815 $dt=42
C159 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=151350 $Y=37085 $dt=42
C160 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=151350 $Y=48785 $dt=42
C161 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=151350 $Y=60485 $dt=42
C162 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=154325 $Y=79030 $dt=42
C163 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=154325 $Y=90730 $dt=42
C164 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=157095 $Y=10115 $dt=42
C165 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=157095 $Y=21815 $dt=42
C166 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=157390 $Y=37085 $dt=42
C167 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=157390 $Y=48785 $dt=42
C168 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=157390 $Y=60485 $dt=42
C169 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=160365 $Y=79030 $dt=42
C170 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=160365 $Y=90730 $dt=42
C171 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=163135 $Y=10115 $dt=42
C172 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=163135 $Y=21815 $dt=42
C173 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=163430 $Y=37085 $dt=42
C174 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=163430 $Y=48785 $dt=42
C175 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=163430 $Y=60485 $dt=42
C176 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=166405 $Y=79030 $dt=42
C177 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=166405 $Y=90730 $dt=42
C178 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=169175 $Y=10115 $dt=42
C179 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=169175 $Y=21815 $dt=42
C180 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=169470 $Y=37085 $dt=42
C181 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=169470 $Y=48785 $dt=42
C182 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=169470 $Y=60485 $dt=42
C183 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=172445 $Y=79030 $dt=42
C184 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=172445 $Y=90730 $dt=42
C185 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=175215 $Y=10115 $dt=42
C186 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=175215 $Y=21815 $dt=42
C187 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=175510 $Y=37085 $dt=42
C188 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=175510 $Y=48785 $dt=42
C189 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=175510 $Y=60485 $dt=42
C190 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=178485 $Y=79030 $dt=42
C191 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=178485 $Y=90730 $dt=42
C192 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=181255 $Y=10115 $dt=42
C193 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=181255 $Y=21815 $dt=42
C194 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=181550 $Y=37085 $dt=42
C195 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=181550 $Y=48785 $dt=42
C196 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=181550 $Y=60485 $dt=42
C197 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=187295 $Y=10115 $dt=42
C198 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=187295 $Y=21815 $dt=42
C199 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=187590 $Y=37085 $dt=42
C200 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=187590 $Y=48785 $dt=42
C201 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=187590 $Y=60485 $dt=42
C202 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=193335 $Y=10115 $dt=42
C203 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=193335 $Y=21815 $dt=42
C204 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=193630 $Y=37085 $dt=42
C205 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=193630 $Y=48785 $dt=42
C206 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=193630 $Y=60485 $dt=42
C207 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=199375 $Y=10115 $dt=42
C208 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=199375 $Y=21815 $dt=42
C209 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=199670 $Y=37085 $dt=42
C210 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=199670 $Y=48785 $dt=42
C211 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=199670 $Y=60485 $dt=42
C212 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=205415 $Y=10115 $dt=42
C213 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=205415 $Y=21815 $dt=42
C214 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=205710 $Y=37085 $dt=42
C215 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=205710 $Y=48785 $dt=42
C216 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=205710 $Y=60485 $dt=42
C217 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=211455 $Y=10115 $dt=42
C218 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=211455 $Y=21815 $dt=42
C219 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=211750 $Y=37085 $dt=42
C220 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=211750 $Y=48785 $dt=42
C221 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=211750 $Y=60485 $dt=42
C222 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=217495 $Y=10115 $dt=42
C223 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=217495 $Y=21815 $dt=42
C224 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=217790 $Y=37085 $dt=42
C225 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=217790 $Y=48785 $dt=42
C226 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=217790 $Y=60485 $dt=42
C227 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=223535 $Y=10115 $dt=42
C228 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=223535 $Y=21815 $dt=42
C229 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=223830 $Y=37085 $dt=42
C230 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=223830 $Y=48785 $dt=42
C231 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=223830 $Y=60485 $dt=42
C232 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=229575 $Y=10115 $dt=42
C233 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=229575 $Y=21815 $dt=42
C234 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=229870 $Y=37085 $dt=42
C235 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=229870 $Y=48785 $dt=42
C236 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=229870 $Y=60485 $dt=42
C237 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=235615 $Y=10115 $dt=42
C238 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=235615 $Y=21815 $dt=42
C239 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=235910 $Y=37085 $dt=42
C240 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=235910 $Y=48785 $dt=42
C241 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=235910 $Y=60485 $dt=42
C242 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=241655 $Y=10115 $dt=42
C243 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=241655 $Y=21815 $dt=42
C244 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=241950 $Y=37085 $dt=42
C245 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=241950 $Y=48785 $dt=42
C246 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=241950 $Y=60485 $dt=42
C247 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=247695 $Y=10115 $dt=42
C248 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=247695 $Y=21815 $dt=42
C249 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=247990 $Y=37085 $dt=42
C250 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=247990 $Y=48785 $dt=42
C251 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=247990 $Y=60485 $dt=42
C252 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=253735 $Y=10115 $dt=42
C253 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=253735 $Y=21815 $dt=42
C254 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=254030 $Y=37085 $dt=42
C255 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=254030 $Y=48785 $dt=42
C256 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=254030 $Y=60485 $dt=42
C257 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=259775 $Y=10115 $dt=42
C258 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=259775 $Y=21815 $dt=42
C259 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=260070 $Y=37085 $dt=42
C260 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=260070 $Y=48785 $dt=42
C261 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=260070 $Y=60485 $dt=42
C262 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=265815 $Y=10115 $dt=42
C263 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=265815 $Y=21815 $dt=42
C264 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=266110 $Y=37085 $dt=42
C265 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=266110 $Y=48785 $dt=42
C266 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=266110 $Y=60485 $dt=42
C267 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=271855 $Y=10115 $dt=42
C268 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=271855 $Y=21815 $dt=42
C269 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=272150 $Y=37085 $dt=42
C270 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=272150 $Y=48785 $dt=42
C271 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=272150 $Y=60485 $dt=42
C272 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=277895 $Y=10115 $dt=42
C273 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=277895 $Y=21815 $dt=42
C274 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=278190 $Y=37085 $dt=42
C275 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=278190 $Y=48785 $dt=42
C276 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=278190 $Y=60485 $dt=42
C277 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=283935 $Y=10115 $dt=42
C278 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=283935 $Y=21815 $dt=42
C279 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=284230 $Y=37085 $dt=42
C280 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=284230 $Y=48785 $dt=42
C281 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=284230 $Y=60485 $dt=42
C282 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=289975 $Y=10115 $dt=42
C283 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=289975 $Y=21815 $dt=42
C284 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=290270 $Y=37085 $dt=42
C285 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=290270 $Y=48785 $dt=42
C286 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=290270 $Y=60485 $dt=42
C287 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=296015 $Y=10115 $dt=42
C288 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=296015 $Y=21815 $dt=42
C289 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=296310 $Y=37085 $dt=42
C290 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=296310 $Y=48785 $dt=42
C291 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=296310 $Y=60485 $dt=42
C292 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=302055 $Y=10115 $dt=42
C293 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=302055 $Y=21815 $dt=42
C294 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=302350 $Y=37085 $dt=42
C295 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=302350 $Y=48785 $dt=42
C296 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=302350 $Y=60485 $dt=42
C297 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=308095 $Y=10115 $dt=42
C298 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=308095 $Y=21815 $dt=42
C299 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=308390 $Y=37085 $dt=42
C300 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=308390 $Y=48785 $dt=42
C301 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=308390 $Y=60485 $dt=42
C302 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=314135 $Y=10115 $dt=42
C303 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=314135 $Y=21815 $dt=42
C304 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=314430 $Y=37085 $dt=42
C305 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=314430 $Y=48785 $dt=42
C306 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=314430 $Y=60485 $dt=42
C307 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=320175 $Y=10115 $dt=42
C308 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=320175 $Y=21815 $dt=42
C309 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=320470 $Y=37085 $dt=42
C310 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=320470 $Y=48785 $dt=42
C311 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=320470 $Y=60485 $dt=42
C312 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=326215 $Y=10115 $dt=42
C313 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=326215 $Y=21815 $dt=42
C314 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=326510 $Y=37085 $dt=42
C315 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=326510 $Y=48785 $dt=42
C316 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=326510 $Y=60485 $dt=42
C317 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=332255 $Y=10115 $dt=42
C318 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=332255 $Y=21815 $dt=42
C319 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=332550 $Y=37085 $dt=42
C320 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=332550 $Y=48785 $dt=42
C321 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=332550 $Y=60485 $dt=42
C322 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=338295 $Y=10115 $dt=42
C323 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=338295 $Y=21815 $dt=42
C324 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=338590 $Y=37085 $dt=42
C325 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=338590 $Y=48785 $dt=42
C326 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=338590 $Y=60485 $dt=42
C327 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=344335 $Y=10115 $dt=42
C328 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=344335 $Y=21815 $dt=42
C329 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=344630 $Y=37085 $dt=42
C330 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=344630 $Y=48785 $dt=42
C331 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=344630 $Y=60485 $dt=42
C332 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=350375 $Y=10115 $dt=42
C333 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=350375 $Y=21815 $dt=42
C334 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=350670 $Y=37085 $dt=42
C335 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=350670 $Y=48785 $dt=42
C336 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=350670 $Y=60485 $dt=42
C337 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=356415 $Y=10115 $dt=42
C338 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=356415 $Y=21815 $dt=42
C339 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=356710 $Y=37085 $dt=42
C340 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=356710 $Y=48785 $dt=42
C341 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=356710 $Y=60485 $dt=42
C342 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=362455 $Y=10115 $dt=42
C343 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=362455 $Y=21815 $dt=42
C344 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=362750 $Y=37085 $dt=42
C345 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=362750 $Y=48785 $dt=42
C346 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=362750 $Y=60485 $dt=42
C347 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=368495 $Y=10115 $dt=42
C348 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=368495 $Y=21815 $dt=42
C349 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=368790 $Y=37085 $dt=42
C350 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=368790 $Y=48785 $dt=42
C351 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=368790 $Y=60485 $dt=42
C352 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=374535 $Y=10115 $dt=42
C353 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=374535 $Y=21815 $dt=42
C354 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=374830 $Y=37085 $dt=42
C355 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=374830 $Y=48785 $dt=42
C356 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=374830 $Y=60485 $dt=42
C357 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=380575 $Y=10115 $dt=42
C358 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=380575 $Y=21815 $dt=42
C359 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=380870 $Y=37085 $dt=42
C360 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=380870 $Y=48785 $dt=42
C361 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=380870 $Y=60485 $dt=42
C362 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=386615 $Y=10115 $dt=42
C363 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=386615 $Y=21815 $dt=42
C364 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=386910 $Y=37085 $dt=42
C365 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=386910 $Y=48785 $dt=42
C366 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=386910 $Y=60485 $dt=42
C367 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=392655 $Y=10115 $dt=42
C368 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=392655 $Y=21815 $dt=42
C369 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=392950 $Y=37085 $dt=42
C370 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=392950 $Y=48785 $dt=42
C371 2 3 area=6.3936e-11 perimeter=3.372e-05 $[csf4a] $X=392950 $Y=60485 $dt=42
.ends hvswitch8

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: hbridge_4x                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt hbridge_4x 1 2 3 4 5 6 7 8 9 10
+ 11 12 13 14 15 16 17 18
** N=18 EP=18 FDC=1732
X0 18 10 15 9 16 1 17 2 12 hvswitch8 $T=500 3780 0 0 $X=6300 $Y=11260
X1 18 10 14 9 16 3 17 4 12 hvswitch8 $T=500 246270 0 0 $X=6300 $Y=253750
X2 18 10 13 9 16 5 17 6 12 hvswitch8 $T=500 488760 0 0 $X=6300 $Y=496240
X3 18 10 11 9 16 7 17 8 12 hvswitch8 $T=500 731330 0 0 $X=6300 $Y=738810
.ends hbridge_4x

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938311                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938311 1 2 3 4
** N=4 EP=4 FDC=4
M0 3 2 1 4 ne3 L=5e-07 W=5e-06 AD=1.35e-12 AS=2.4e-12 PD=5.54e-06 PS=1.096e-05 $X=0 $Y=0 $dt=3
M1 1 2 3 4 ne3 L=5e-07 W=5e-06 AD=1.35e-12 AS=1.35e-12 PD=5.54e-06 PS=5.54e-06 $X=1040 $Y=0 $dt=3
M2 3 2 1 4 ne3 L=5e-07 W=5e-06 AD=1.35e-12 AS=1.35e-12 PD=5.54e-06 PS=5.54e-06 $X=2080 $Y=0 $dt=3
M3 1 2 3 4 ne3 L=5e-07 W=5e-06 AD=2.4e-12 AS=1.35e-12 PD=1.096e-05 PS=5.54e-06 $X=3120 $Y=0 $dt=3
.ends ne3_CDNS_7290843938311

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_CDNS_7290843938312                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_CDNS_7290843938312 1 2 3 4
** N=4 EP=4 FDC=1
X0 2 4 3 1 LDDN w=5e-05 l=1.25e-06 adio=1.08602e-09 pdio=0.00013535 extlay=1 $[nedia] $X=-680 $Y=-4850 $dt=1
.ends nedia_CDNS_7290843938312

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938313                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938313 1 2 3 4
** N=4 EP=4 FDC=4
M0 3 2 1 4 ne3 L=3.5e-07 W=5e-06 AD=1.35e-12 AS=2.4e-12 PD=5.54e-06 PS=1.096e-05 $X=0 $Y=0 $dt=3
M1 1 2 3 4 ne3 L=3.5e-07 W=5e-06 AD=1.35e-12 AS=1.35e-12 PD=5.54e-06 PS=5.54e-06 $X=890 $Y=0 $dt=3
M2 3 2 1 4 ne3 L=3.5e-07 W=5e-06 AD=1.35e-12 AS=1.35e-12 PD=5.54e-06 PS=5.54e-06 $X=1780 $Y=0 $dt=3
M3 1 2 3 4 ne3 L=3.5e-07 W=5e-06 AD=2.4e-12 AS=1.35e-12 PD=1.096e-05 PS=5.54e-06 $X=2670 $Y=0 $dt=3
.ends ne3_CDNS_7290843938313

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938314                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938314 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.00010265 W=4e-06 $[rpp1k1_3] $SUB=3 $X=0 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938314

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nedia_CDNS_7290843938315                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nedia_CDNS_7290843938315 1 2 3 4
** N=4 EP=4 FDC=8
X0 2 4 3 1 LDDN w=0.0001 l=1.25e-06 adio=1.01941e-09 pdio=4.39938e-05 extlay=1 $[nedia] $X=-680 $Y=-4850 $dt=1
X1 2 4 3 1 LDDN w=0.0001 l=1.25e-06 adio=1.01941e-09 pdio=4.39938e-05 extlay=1 $[nedia] $X=11220 $Y=-4850 $dt=1
X2 2 4 3 1 LDDN w=0.0001 l=1.25e-06 adio=1.01941e-09 pdio=4.39938e-05 extlay=1 $[nedia] $X=23120 $Y=-4850 $dt=1
X3 2 4 3 1 LDDN w=0.0001 l=1.25e-06 adio=1.01941e-09 pdio=4.39938e-05 extlay=1 $[nedia] $X=35020 $Y=-4850 $dt=1
X4 2 4 3 1 LDDN w=0.0001 l=1.25e-06 adio=1.01941e-09 pdio=4.39938e-05 extlay=1 $[nedia] $X=46920 $Y=-4850 $dt=1
X5 2 4 3 1 LDDN w=0.0001 l=1.25e-06 adio=1.01941e-09 pdio=4.39938e-05 extlay=1 $[nedia] $X=58820 $Y=-4850 $dt=1
X6 2 4 3 1 LDDN w=0.0001 l=1.25e-06 adio=1.01941e-09 pdio=4.39938e-05 extlay=1 $[nedia] $X=70720 $Y=-4850 $dt=1
X7 2 4 3 1 LDDN w=0.0001 l=1.25e-06 adio=1.01941e-09 pdio=4.39938e-05 extlay=1 $[nedia] $X=82620 $Y=-4850 $dt=1
.ends nedia_CDNS_7290843938315

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938316                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938316 1 2 3 4
** N=4 EP=4 FDC=2
M0 3 2 1 4 ne3 L=1e-05 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=3
M1 1 2 3 4 ne3 L=1e-05 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=10540 $Y=0 $dt=3
.ends ne3_CDNS_7290843938316

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938317                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938317 1 2 3 4
*.DEVICECLIMB
** N=5 EP=4 FDC=1
M0 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
.ends pe3_CDNS_7290843938317

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938318                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938318 1 2 3
*.DEVICECLIMB
** N=4 EP=3 FDC=2
M0 3 2 1 1 pe3 L=3e-07 W=3e-06 AD=8.1e-13 AS=1.44e-12 PD=3.54e-06 PS=6.96e-06 $X=0 $Y=0 $dt=4
M1 1 2 3 1 pe3 L=3e-07 W=3e-06 AD=1.44e-12 AS=8.1e-13 PD=6.96e-06 PS=3.54e-06 $X=840 $Y=0 $dt=4
.ends pe3_CDNS_7290843938318

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938319                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938319 1 2 3
** N=3 EP=3 FDC=1
R0 1 2 L=0.00204354 W=2e-06 $[rpp1k1_3] $SUB=3 $X=-2220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938319

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938322                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938322 1 2 3 4
*.DEVICECLIMB
** N=5 EP=4 FDC=1
M0 3 2 1 4 pe3 L=5e-06 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
.ends pe3_CDNS_7290843938322

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938323                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938323 1 2 3 4
** N=4 EP=4 FDC=1
M0 3 2 1 4 ne3 L=1e-05 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=3
.ends ne3_CDNS_7290843938323

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938324                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938324 1 2 3 4
** N=4 EP=4 FDC=1
M0 3 2 1 4 ne3 L=1e-06 W=5e-06 AD=2.4e-12 AS=2.4e-12 PD=1.096e-05 PS=1.096e-05 $X=0 $Y=0 $dt=3
.ends ne3_CDNS_7290843938324

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938325                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938325 1 2 3 4
** N=4 EP=4 FDC=10
M0 3 2 1 1 pe3 L=5e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 1 pe3 L=5e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=5540 $Y=0 $dt=4
M2 3 2 1 1 pe3 L=5e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=11080 $Y=0 $dt=4
M3 1 2 3 1 pe3 L=5e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=16620 $Y=0 $dt=4
M4 3 2 1 1 pe3 L=5e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=22160 $Y=0 $dt=4
M5 1 2 3 1 pe3 L=5e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=27700 $Y=0 $dt=4
M6 3 2 1 1 pe3 L=5e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=33240 $Y=0 $dt=4
M7 1 2 3 1 pe3 L=5e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=38780 $Y=0 $dt=4
M8 3 2 1 1 pe3 L=5e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=44320 $Y=0 $dt=4
D9 4 1 p_dnw3 AREA=5.86064e-10 PJ=7.406e-05 perimeter=7.406e-05 $X=-910 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938325

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938326                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938326 1 2 3
** N=3 EP=3 FDC=1
R0 1 2 L=1e-05 W=2e-06 $[rpp1k1_3] $SUB=3 $X=0 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938326

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938327                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938327 1 2 3
*.DEVICECLIMB
** N=4 EP=3 FDC=1
R0 2 1 L=0.00016435 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=38
.ends rpp1k1_3_CDNS_7290843938327

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938328                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938328 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.00041122 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938328

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938329                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938329 1 2 3 4
** N=4 EP=4 FDC=1
M0 3 2 1 4 ne3 L=3.5e-07 W=2e-06 AD=9.6e-13 AS=9.6e-13 PD=4.96e-06 PS=4.96e-06 $X=0 $Y=0 $dt=3
.ends ne3_CDNS_7290843938329

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: current_source_gm_10_en_r                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt current_source_gm_10_en_r 1 2 3 4 5 6 7 8 9 10
+ 11
*.DEVICECLIMB
** N=28 EP=11 FDC=197
X5 1 13 14 8 ne3_CDNS_7290843938311 $T=248120 21400 0 0 $X=247320 $Y=21000
X6 8 15 9 14 nedia_CDNS_7290843938312 $T=282450 37820 0 0 $X=266230 $Y=18430
X7 1 16 17 8 ne3_CDNS_7290843938313 $T=25060 81535 0 0 $X=24260 $Y=80955
X8 1 18 13 8 ne3_CDNS_7290843938313 $T=30635 81535 0 0 $X=29835 $Y=80955
X9 15 9 8 rpp1k1_3_CDNS_7290843938314 $T=317545 27490 0 90 $X=309065 $Y=26550
X10 8 11 7 15 nedia_CDNS_7290843938315 $T=441980 141045 0 270 $X=422590 $Y=41525
X11 17 4 4 8 ne3_CDNS_7290843938316 $T=8060 64240 0 0 $X=7260 $Y=63840
X12 19 4 20 8 ne3_CDNS_7290843938316 $T=33845 64240 0 0 $X=33045 $Y=63840
X13 21 4 22 8 ne3_CDNS_7290843938316 $T=59570 64240 0 0 $X=58770 $Y=63840
X14 2 20 14 2 pe3_CDNS_7290843938317 $T=63965 94930 0 180 $X=61455 $Y=83900
X15 2 20 14 2 pe3_CDNS_7290843938317 $T=66205 94930 0 180 $X=63695 $Y=83900
X16 2 20 20 2 pe3_CDNS_7290843938317 $T=68445 94930 0 180 $X=65935 $Y=83900
X17 2 20 14 2 pe3_CDNS_7290843938317 $T=70685 94930 0 180 $X=68175 $Y=83900
X18 2 20 14 2 pe3_CDNS_7290843938317 $T=72925 94930 0 180 $X=70415 $Y=83900
X19 2 3 16 pe3_CDNS_7290843938318 $T=15530 89865 0 180 $X=13480 $Y=86295
X20 2 5 18 pe3_CDNS_7290843938318 $T=19690 89865 0 180 $X=17640 $Y=86295
X21 9 11 8 rpp1k1_3_CDNS_7290843938319 $T=558265 45130 0 90 $X=515365 $Y=41970
X22 2 2 2 2 pe3_CDNS_7290843938322 $T=109700 69700 0 0 $X=108190 $Y=68670
X23 2 2 2 2 pe3_CDNS_7290843938322 $T=109700 93320 1 0 $X=108190 $Y=82290
X24 2 2 2 2 pe3_CDNS_7290843938322 $T=113660 125985 0 0 $X=112150 $Y=124955
X25 2 2 2 2 pe3_CDNS_7290843938322 $T=113660 148965 1 0 $X=112150 $Y=137935
X26 23 24 13 2 pe3_CDNS_7290843938322 $T=115940 69700 0 0 $X=114430 $Y=68670
X27 23 25 26 2 pe3_CDNS_7290843938322 $T=115940 93320 1 0 $X=114430 $Y=82290
X28 2 22 23 2 pe3_CDNS_7290843938322 $T=119900 125985 0 0 $X=118390 $Y=124955
X29 2 22 23 2 pe3_CDNS_7290843938322 $T=119900 148965 1 0 $X=118390 $Y=137935
X30 23 25 26 2 pe3_CDNS_7290843938322 $T=122180 69700 0 0 $X=120670 $Y=68670
X31 23 24 13 2 pe3_CDNS_7290843938322 $T=122180 93320 1 0 $X=120670 $Y=82290
X32 2 22 23 2 pe3_CDNS_7290843938322 $T=126140 125985 0 0 $X=124630 $Y=124955
X33 2 22 23 2 pe3_CDNS_7290843938322 $T=126140 148965 1 0 $X=124630 $Y=137935
X34 23 24 13 2 pe3_CDNS_7290843938322 $T=128420 69700 0 0 $X=126910 $Y=68670
X35 23 25 26 2 pe3_CDNS_7290843938322 $T=128420 93320 1 0 $X=126910 $Y=82290
X36 2 22 23 2 pe3_CDNS_7290843938322 $T=132380 125985 0 0 $X=130870 $Y=124955
X37 2 22 23 2 pe3_CDNS_7290843938322 $T=132380 148965 1 0 $X=130870 $Y=137935
X38 23 25 26 2 pe3_CDNS_7290843938322 $T=134660 69700 0 0 $X=133150 $Y=68670
X39 23 24 13 2 pe3_CDNS_7290843938322 $T=134660 93320 1 0 $X=133150 $Y=82290
X40 2 22 23 2 pe3_CDNS_7290843938322 $T=138620 125985 0 0 $X=137110 $Y=124955
X41 2 22 23 2 pe3_CDNS_7290843938322 $T=138620 148965 1 0 $X=137110 $Y=137935
X42 23 24 13 2 pe3_CDNS_7290843938322 $T=140900 69700 0 0 $X=139390 $Y=68670
X43 23 25 26 2 pe3_CDNS_7290843938322 $T=140900 93320 1 0 $X=139390 $Y=82290
X44 2 22 23 2 pe3_CDNS_7290843938322 $T=144860 125985 0 0 $X=143350 $Y=124955
X45 2 22 23 2 pe3_CDNS_7290843938322 $T=144860 148965 1 0 $X=143350 $Y=137935
X46 23 25 26 2 pe3_CDNS_7290843938322 $T=147140 69700 0 0 $X=145630 $Y=68670
X47 23 24 13 2 pe3_CDNS_7290843938322 $T=147140 93320 1 0 $X=145630 $Y=82290
X48 2 22 24 2 pe3_CDNS_7290843938322 $T=151100 125985 0 0 $X=149590 $Y=124955
X49 2 22 25 2 pe3_CDNS_7290843938322 $T=151100 148965 1 0 $X=149590 $Y=137935
X50 23 24 13 2 pe3_CDNS_7290843938322 $T=153380 69700 0 0 $X=151870 $Y=68670
X51 23 25 26 2 pe3_CDNS_7290843938322 $T=153380 93320 1 0 $X=151870 $Y=82290
X52 2 22 22 2 pe3_CDNS_7290843938322 $T=157340 125985 0 0 $X=155830 $Y=124955
X53 2 22 22 2 pe3_CDNS_7290843938322 $T=157340 148965 1 0 $X=155830 $Y=137935
X54 23 25 26 2 pe3_CDNS_7290843938322 $T=159620 69700 0 0 $X=158110 $Y=68670
X55 23 24 13 2 pe3_CDNS_7290843938322 $T=159620 93320 1 0 $X=158110 $Y=82290
X56 2 22 25 2 pe3_CDNS_7290843938322 $T=163580 125985 0 0 $X=162070 $Y=124955
X57 2 22 24 2 pe3_CDNS_7290843938322 $T=163580 148965 1 0 $X=162070 $Y=137935
X58 23 24 13 2 pe3_CDNS_7290843938322 $T=165860 69700 0 0 $X=164350 $Y=68670
X59 23 25 26 2 pe3_CDNS_7290843938322 $T=165860 93320 1 0 $X=164350 $Y=82290
X60 2 22 23 2 pe3_CDNS_7290843938322 $T=169820 125985 0 0 $X=168310 $Y=124955
X61 2 22 23 2 pe3_CDNS_7290843938322 $T=169820 148965 1 0 $X=168310 $Y=137935
X62 23 25 26 2 pe3_CDNS_7290843938322 $T=172100 69700 0 0 $X=170590 $Y=68670
X63 23 24 13 2 pe3_CDNS_7290843938322 $T=172100 93320 1 0 $X=170590 $Y=82290
X64 2 22 23 2 pe3_CDNS_7290843938322 $T=176060 125985 0 0 $X=174550 $Y=124955
X65 2 22 23 2 pe3_CDNS_7290843938322 $T=176060 148965 1 0 $X=174550 $Y=137935
X66 23 24 13 2 pe3_CDNS_7290843938322 $T=178340 69700 0 0 $X=176830 $Y=68670
X67 23 25 26 2 pe3_CDNS_7290843938322 $T=178340 93320 1 0 $X=176830 $Y=82290
X68 2 22 23 2 pe3_CDNS_7290843938322 $T=182300 125985 0 0 $X=180790 $Y=124955
X69 2 22 23 2 pe3_CDNS_7290843938322 $T=182300 148965 1 0 $X=180790 $Y=137935
X70 23 25 26 2 pe3_CDNS_7290843938322 $T=184580 69700 0 0 $X=183070 $Y=68670
X71 23 24 13 2 pe3_CDNS_7290843938322 $T=184580 93320 1 0 $X=183070 $Y=82290
X72 2 22 23 2 pe3_CDNS_7290843938322 $T=188540 125985 0 0 $X=187030 $Y=124955
X73 2 22 23 2 pe3_CDNS_7290843938322 $T=188540 148965 1 0 $X=187030 $Y=137935
X74 23 24 13 2 pe3_CDNS_7290843938322 $T=190820 69700 0 0 $X=189310 $Y=68670
X75 23 25 26 2 pe3_CDNS_7290843938322 $T=190820 93320 1 0 $X=189310 $Y=82290
X76 2 22 23 2 pe3_CDNS_7290843938322 $T=194780 125985 0 0 $X=193270 $Y=124955
X77 2 22 23 2 pe3_CDNS_7290843938322 $T=194780 148965 1 0 $X=193270 $Y=137935
X78 23 25 26 2 pe3_CDNS_7290843938322 $T=197060 69700 0 0 $X=195550 $Y=68670
X79 23 24 13 2 pe3_CDNS_7290843938322 $T=197060 93320 1 0 $X=195550 $Y=82290
X80 2 2 2 2 pe3_CDNS_7290843938322 $T=201020 125985 0 0 $X=199510 $Y=124955
X81 2 2 2 2 pe3_CDNS_7290843938322 $T=201020 148965 1 0 $X=199510 $Y=137935
X82 2 2 2 2 pe3_CDNS_7290843938322 $T=203300 69700 0 0 $X=201790 $Y=68670
X83 2 2 2 2 pe3_CDNS_7290843938322 $T=203300 93320 1 0 $X=201790 $Y=82290
X84 1 1 1 8 ne3_CDNS_7290843938323 $T=17420 20740 0 0 $X=16620 $Y=20340
X85 1 1 1 8 ne3_CDNS_7290843938323 $T=17420 42860 1 0 $X=16620 $Y=32290
X86 1 17 21 8 ne3_CDNS_7290843938323 $T=28660 20740 0 0 $X=27860 $Y=20340
X87 1 17 21 8 ne3_CDNS_7290843938323 $T=28660 42860 1 0 $X=27860 $Y=32290
X88 1 17 17 8 ne3_CDNS_7290843938323 $T=39900 20740 0 0 $X=39100 $Y=20340
X89 1 17 17 8 ne3_CDNS_7290843938323 $T=39900 42860 1 0 $X=39100 $Y=32290
X90 1 17 19 8 ne3_CDNS_7290843938323 $T=51140 20740 0 0 $X=50340 $Y=20340
X91 1 17 19 8 ne3_CDNS_7290843938323 $T=51140 42860 1 0 $X=50340 $Y=32290
X92 1 1 1 8 ne3_CDNS_7290843938323 $T=62380 20740 0 0 $X=61580 $Y=20340
X93 1 1 1 8 ne3_CDNS_7290843938323 $T=62380 42860 1 0 $X=61580 $Y=32290
X94 1 26 13 8 ne3_CDNS_7290843938324 $T=232175 21040 0 0 $X=231375 $Y=20640
X95 1 26 26 8 ne3_CDNS_7290843938324 $T=232175 32430 1 0 $X=231375 $Y=26860
X96 1 26 26 8 ne3_CDNS_7290843938324 $T=234415 21040 0 0 $X=233615 $Y=20640
X97 1 26 13 8 ne3_CDNS_7290843938324 $T=234415 32430 1 0 $X=233615 $Y=26860
X98 25 6 1 8 pe3_CDNS_7290843938325 $T=106815 19890 0 0 $X=105305 $Y=18860
X99 24 27 1 8 pe3_CDNS_7290843938325 $T=106815 43890 1 0 $X=105305 $Y=32860
X100 24 27 1 8 pe3_CDNS_7290843938325 $T=161095 19890 0 0 $X=159585 $Y=18860
X101 25 6 1 8 pe3_CDNS_7290843938325 $T=161095 43890 1 0 $X=159585 $Y=32860
X102 7 27 8 rpp1k1_3_CDNS_7290843938326 $T=229190 61300 0 90 $X=226970 $Y=60360
X103 7 27 8 rpp1k1_3_CDNS_7290843938326 $T=232060 61300 0 90 $X=229840 $Y=60360
X104 7 27 8 rpp1k1_3_CDNS_7290843938326 $T=234930 61300 0 90 $X=232710 $Y=60360
X105 7 27 8 rpp1k1_3_CDNS_7290843938326 $T=237800 61300 0 90 $X=235580 $Y=60360
X106 7 27 8 rpp1k1_3_CDNS_7290843938326 $T=240670 61300 0 90 $X=238450 $Y=60360
X107 7 27 8 rpp1k1_3_CDNS_7290843938326 $T=243540 61300 0 90 $X=241320 $Y=60360
X108 7 27 8 rpp1k1_3_CDNS_7290843938326 $T=246410 61300 0 90 $X=244190 $Y=60360
X109 7 27 8 rpp1k1_3_CDNS_7290843938326 $T=249280 61300 0 90 $X=247060 $Y=60360
X110 7 27 8 rpp1k1_3_CDNS_7290843938326 $T=252150 61300 0 90 $X=249930 $Y=60360
X111 14 28 2 rpp1k1_3_CDNS_7290843938327 $T=255085 124550 0 180 $X=228430 $Y=99030
X112 10 15 8 rpp1k1_3_CDNS_7290843938328 $T=322885 76685 0 270 $X=322665 $Y=25845
X113 1 3 16 8 ne3_CDNS_7290843938329 $T=14340 81020 0 0 $X=13540 $Y=80620
X114 1 5 18 8 ne3_CDNS_7290843938329 $T=18500 81020 0 0 $X=17700 $Y=80620
X763 2 1 8 MOSVC3 w=2e-05 l=3e-05 $X=16180 $Y=110530 $dt=8
X764 2 1 8 MOSVC3 w=2e-05 l=3e-05 $X=16180 $Y=132530 $dt=8
X765 2 1 8 MOSVC3 w=2e-05 l=3e-05 $X=48780 $Y=110530 $dt=8
X766 2 1 8 MOSVC3 w=2e-05 l=3e-05 $X=48780 $Y=132530 $dt=8
D4 8 2 p_dnw AREA=3.57048e-11 PJ=3.588e-05 perimeter=3.588e-05 $X=11740 $Y=84695 $dt=12
D5 8 2 p_dnw AREA=1.90124e-10 PJ=7.516e-05 perimeter=7.516e-05 $X=59815 $Y=81480 $dt=12
D6 8 2 p_dnw AREA=1.58288e-09 PJ=0.00049318 perimeter=0.00049318 $X=99710 $Y=59910 $dt=12
D7 8 2 p_dnw AREA=3.09086e-09 PJ=0.00032604 perimeter=0.00032604 $X=101390 $Y=114415 $dt=12
D8 8 25 p_dnw AREA=1.82058e-10 PJ=5.826e-05 perimeter=5.826e-05 $X=105905 $Y=15300 $dt=12
D9 8 24 p_dnw AREA=1.82058e-10 PJ=5.826e-05 perimeter=5.826e-05 $X=105905 $Y=44920 $dt=12
D10 8 24 p_dnw AREA=1.82058e-10 PJ=5.826e-05 perimeter=5.826e-05 $X=160185 $Y=15300 $dt=12
D11 8 25 p_dnw AREA=1.82058e-10 PJ=5.826e-05 perimeter=5.826e-05 $X=160185 $Y=44920 $dt=12
D12 8 2 p_dnw AREA=8.36476e-09 PJ=0.0003905 perimeter=0.0003905 $X=226790 $Y=95600 $dt=12
D13 8 2 p_dnw3 AREA=4.20992e-11 PJ=0 perimeter=0 $X=12880 $Y=85835 $dt=36
D14 8 1 p_dnw3 AREA=5.9176e-11 PJ=0.00010492 perimeter=0.00010492 $X=15380 $Y=110100 $dt=36
D15 8 1 p_dnw3 AREA=5.9176e-11 PJ=0.00010492 perimeter=0.00010492 $X=15380 $Y=132100 $dt=36
D16 8 1 p_dnw3 AREA=5.9176e-11 PJ=0.00010492 perimeter=0.00010492 $X=47980 $Y=110100 $dt=36
D17 8 1 p_dnw3 AREA=5.9176e-11 PJ=0.00010492 perimeter=0.00010492 $X=47980 $Y=132100 $dt=36
D18 8 2 p_dnw3 AREA=1.56539e-10 PJ=0 perimeter=0 $X=61455 $Y=83900 $dt=36
D19 8 2 p_dnw3 AREA=1.22554e-09 PJ=0 perimeter=0 $X=108190 $Y=68670 $dt=36
D20 8 2 p_dnw3 AREA=1.15225e-09 PJ=0.00012214 perimeter=0.00012214 $X=108190 $Y=82290 $dt=36
D21 8 2 p_dnw3 AREA=1.15028e-09 PJ=0 perimeter=0 $X=112150 $Y=124955 $dt=36
D22 8 2 p_dnw3 AREA=1.15028e-09 PJ=0 perimeter=0 $X=112150 $Y=137935 $dt=36
C23 13 28 area=8.4e-10 perimeter=0.000116 $[cmm5t] $X=231620 $Y=128940 $dt=43
C24 13 28 area=8.4e-10 perimeter=0.000116 $[cmm5t] $X=263220 $Y=97740 $dt=43
C25 13 28 area=8.4e-10 perimeter=0.000116 $[cmm5t] $X=263220 $Y=128940 $dt=43
C26 13 28 area=8.4e-10 perimeter=0.000116 $[cmm5t] $X=294820 $Y=97740 $dt=43
C27 13 28 area=8.4e-10 perimeter=0.000116 $[cmm5t] $X=294820 $Y=128940 $dt=43
C28 13 28 area=8.4e-10 perimeter=0.000116 $[cmm5t] $X=326420 $Y=97740 $dt=43
C29 13 28 area=8.4e-10 perimeter=0.000116 $[cmm5t] $X=326420 $Y=128940 $dt=43
.ends current_source_gm_10_en_r

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: mosvc3_CDNS_7290843938332                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt mosvc3_CDNS_7290843938332 1 2 3
** N=3 EP=3 FDC=2
X0 2 1 3 MOSVC3 w=2.5e-05 l=2e-05 $X=0 $Y=0 $dt=8
D1 3 1 p_dnw3 AREA=5.8576e-11 PJ=9.492e-05 perimeter=9.492e-05 $X=-800 $Y=-430 $dt=36
.ends mosvc3_CDNS_7290843938332

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: mosvc3_CDNS_7290843938333                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt mosvc3_CDNS_7290843938333 1 2 3
** N=3 EP=3 FDC=2
X0 2 1 3 MOSVC3 w=2e-05 l=2e-05 $X=0 $Y=0 $dt=8
D1 3 1 p_dnw3 AREA=5.0576e-11 PJ=8.492e-05 perimeter=8.492e-05 $X=-800 $Y=-430 $dt=36
.ends mosvc3_CDNS_7290843938333

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938334                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938334 1 2 3
*.DEVICECLIMB
** N=4 EP=3 FDC=1
M0 3 2 1 1 pe3 L=1e-05 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
.ends pe3_CDNS_7290843938334

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938335                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938335 1 2 3 4 5
** N=5 EP=5 FDC=3
M0 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=1540 $Y=0 $dt=4
D2 5 4 p_dnw3 AREA=6.70536e-11 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938335

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938336                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938336 1 2 3 4 5
** N=5 EP=5 FDC=5
M0 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=1540 $Y=0 $dt=4
M2 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=3080 $Y=0 $dt=4
M3 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=4620 $Y=0 $dt=4
D4 5 4 p_dnw3 AREA=1.04198e-10 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938336

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938337                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938337 1 2 3 4 5
** N=5 EP=5 FDC=9
M0 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=1540 $Y=0 $dt=4
M2 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=3080 $Y=0 $dt=4
M3 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=4620 $Y=0 $dt=4
M4 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=6160 $Y=0 $dt=4
M5 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=7700 $Y=0 $dt=4
M6 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=9240 $Y=0 $dt=4
M7 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=10780 $Y=0 $dt=4
D8 5 4 p_dnw3 AREA=1.78488e-10 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938337

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938338                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938338 1 2 3 4 5
** N=5 EP=5 FDC=17
M0 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=1540 $Y=0 $dt=4
M2 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=3080 $Y=0 $dt=4
M3 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=4620 $Y=0 $dt=4
M4 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=6160 $Y=0 $dt=4
M5 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=7700 $Y=0 $dt=4
M6 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=9240 $Y=0 $dt=4
M7 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=10780 $Y=0 $dt=4
M8 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=12320 $Y=0 $dt=4
M9 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=13860 $Y=0 $dt=4
M10 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=15400 $Y=0 $dt=4
M11 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=16940 $Y=0 $dt=4
M12 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=18480 $Y=0 $dt=4
M13 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=20020 $Y=0 $dt=4
M14 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=21560 $Y=0 $dt=4
M15 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=23100 $Y=0 $dt=4
D16 5 4 p_dnw3 AREA=3.27067e-10 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938338

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938339                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938339 1 2 3 4 5
** N=5 EP=5 FDC=33
M0 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=1540 $Y=0 $dt=4
M2 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=3080 $Y=0 $dt=4
M3 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=4620 $Y=0 $dt=4
M4 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=6160 $Y=0 $dt=4
M5 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=7700 $Y=0 $dt=4
M6 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=9240 $Y=0 $dt=4
M7 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=10780 $Y=0 $dt=4
M8 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=12320 $Y=0 $dt=4
M9 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=13860 $Y=0 $dt=4
M10 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=15400 $Y=0 $dt=4
M11 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=16940 $Y=0 $dt=4
M12 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=18480 $Y=0 $dt=4
M13 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=20020 $Y=0 $dt=4
M14 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=21560 $Y=0 $dt=4
M15 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=23100 $Y=0 $dt=4
M16 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=24640 $Y=0 $dt=4
M17 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=26180 $Y=0 $dt=4
M18 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=27720 $Y=0 $dt=4
M19 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=29260 $Y=0 $dt=4
M20 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=30800 $Y=0 $dt=4
M21 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=32340 $Y=0 $dt=4
M22 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=33880 $Y=0 $dt=4
M23 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=35420 $Y=0 $dt=4
M24 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=36960 $Y=0 $dt=4
M25 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=38500 $Y=0 $dt=4
M26 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=40040 $Y=0 $dt=4
M27 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=41580 $Y=0 $dt=4
M28 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=43120 $Y=0 $dt=4
M29 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=44660 $Y=0 $dt=4
M30 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=46200 $Y=0 $dt=4
M31 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=47740 $Y=0 $dt=4
D32 5 4 p_dnw3 AREA=6.24226e-10 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938339

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938340                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938340 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.00021702 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938340

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938341                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938341 1 2 3 4 5
** N=5 EP=5 FDC=11
M0 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=1540 $Y=0 $dt=4
M2 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=3080 $Y=0 $dt=4
M3 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=4620 $Y=0 $dt=4
M4 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=6160 $Y=0 $dt=4
M5 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=7700 $Y=0 $dt=4
M6 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=9240 $Y=0 $dt=4
M7 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=10780 $Y=0 $dt=4
M8 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=12320 $Y=0 $dt=4
M9 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=13860 $Y=0 $dt=4
D10 5 4 p_dnw3 AREA=2.15633e-10 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938341

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938342                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938342 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.0008227 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938342

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938343                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938343 1 2 3
** N=3 EP=3 FDC=2
M0 2 2 1 1 pe3 L=2e-05 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
D1 3 1 p_dnw3 AREA=2.77621e-10 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938343

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938344                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938344 1 2 3
*.DEVICECLIMB
** N=4 EP=3 FDC=1
M0 3 2 1 1 pe3 L=3e-07 W=6e-06 AD=2.88e-12 AS=2.88e-12 PD=1.296e-05 PS=1.296e-05 $X=0 $Y=0 $dt=4
.ends pe3_CDNS_7290843938344

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938345                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938345 1 2 3 4 5
** N=5 EP=5 FDC=3
M0 3 2 1 4 pe3 L=3.5e-07 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 4 pe3 L=3.5e-07 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=890 $Y=0 $dt=4
D2 5 4 p_dnw3 AREA=5.13756e-11 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938345

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938346                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938346 1 2 3 4
** N=4 EP=4 FDC=8
M0 3 2 1 4 ne3 L=2e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=3
M1 1 2 3 4 ne3 L=2e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=2540 $Y=0 $dt=3
M2 3 2 1 4 ne3 L=2e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=5080 $Y=0 $dt=3
M3 1 2 3 4 ne3 L=2e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=7620 $Y=0 $dt=3
M4 3 2 1 4 ne3 L=2e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=10160 $Y=0 $dt=3
M5 1 2 3 4 ne3 L=2e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=12700 $Y=0 $dt=3
M6 3 2 1 4 ne3 L=2e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=15240 $Y=0 $dt=3
M7 1 2 3 4 ne3 L=2e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=17780 $Y=0 $dt=3
.ends ne3_CDNS_7290843938346

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3i_6_CDNS_7290843938347                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3i_6_CDNS_7290843938347 1 2 3 4 5
*.DEVICECLIMB
** N=5 EP=5 FDC=1
X0 1 2 3 1 4 5 NE3I_6 w=1e-05 l=2e-06 as=4.8e-12 ad=4.8e-12 ps=2.096e-05 pd=2.096e-05 $X=0 $Y=0 $dt=7
.ends ne3i_6_CDNS_7290843938347

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938348                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938348 1 2 3 4
** N=4 EP=4 FDC=1
M0 3 2 1 4 ne3 L=2e-06 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=3
.ends ne3_CDNS_7290843938348

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938349                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938349 1
*.DEVICECLIMB
** N=2 EP=1 FDC=1
M0 1 1 1 1 pe3 L=1e-05 W=2e-06 AD=9.6e-13 AS=9.6e-13 PD=4.96e-06 PS=4.96e-06 $X=0 $Y=0 $dt=4
.ends pe3_CDNS_7290843938349

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938350                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938350 1 2 3 4
** N=4 EP=4 FDC=4
M0 3 2 1 4 ne3 L=3.5e-07 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=3
M1 1 2 3 4 ne3 L=3.5e-07 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=890 $Y=0 $dt=3
M2 3 2 1 4 ne3 L=3.5e-07 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=1780 $Y=0 $dt=3
M3 1 2 3 4 ne3 L=3.5e-07 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=2670 $Y=0 $dt=3
.ends ne3_CDNS_7290843938350

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MASCO__A165                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MASCO__A165 1 2 3 4 5 6 7
*.DEVICECLIMB
** N=8 EP=7 FDC=4
X0 1 7 2 pe3_CDNS_7290843938334 $T=1510 11030 1 0 $X=0 $Y=0
X1 1 3 4 pe3_CDNS_7290843938334 $T=12750 11030 1 0 $X=11240 $Y=0
X2 1 3 5 pe3_CDNS_7290843938334 $T=23990 11030 1 0 $X=22480 $Y=0
X3 1 3 6 pe3_CDNS_7290843938334 $T=35230 11030 1 0 $X=33720 $Y=0
.ends MASCO__A165

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: dac6b_amp_n2                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt dac6b_amp_n2 1 2 3 4 5 6 7 8 9 10
+ 11 12 13
** N=32 EP=13 FDC=372
X0 14 15 5 2 pe3_CDNS_7290843938317 $T=373510 36320 1 0 $X=372000 $Y=25290
X1 1 4 16 13 ne3_CDNS_7290843938329 $T=91035 56560 0 0 $X=90235 $Y=56160
X282 2 19 19 pe3_CDNS_7290843938334 $T=15710 148580 0 0 $X=14200 $Y=147550
X283 2 19 23 pe3_CDNS_7290843938334 $T=15710 171560 1 0 $X=14200 $Y=160530
X284 2 19 23 pe3_CDNS_7290843938334 $T=26950 148580 0 0 $X=25440 $Y=147550
X285 2 19 19 pe3_CDNS_7290843938334 $T=26950 171560 1 0 $X=25440 $Y=160530
X286 2 2 2 pe3_CDNS_7290843938334 $T=56340 148580 0 0 $X=54830 $Y=147550
X287 2 20 20 pe3_CDNS_7290843938334 $T=67580 148580 0 0 $X=66070 $Y=147550
X288 2 20 21 pe3_CDNS_7290843938334 $T=78820 148580 0 0 $X=77310 $Y=147550
X289 2 20 20 pe3_CDNS_7290843938334 $T=90060 148580 0 0 $X=88550 $Y=147550
X290 2 20 21 pe3_CDNS_7290843938334 $T=101300 148580 0 0 $X=99790 $Y=147550
X291 2 20 20 pe3_CDNS_7290843938334 $T=112540 148580 0 0 $X=111030 $Y=147550
X292 2 20 21 pe3_CDNS_7290843938334 $T=123780 148580 0 0 $X=122270 $Y=147550
X293 2 20 20 pe3_CDNS_7290843938334 $T=135020 148580 0 0 $X=133510 $Y=147550
X294 2 20 21 pe3_CDNS_7290843938334 $T=146260 148580 0 0 $X=144750 $Y=147550
X295 2 20 20 pe3_CDNS_7290843938334 $T=146260 171560 1 0 $X=144750 $Y=160530
X296 2 2 2 pe3_CDNS_7290843938334 $T=157500 148580 0 0 $X=155990 $Y=147550
X297 2 2 2 pe3_CDNS_7290843938334 $T=157500 171560 1 0 $X=155990 $Y=160530
X298 2 2 2 pe3_CDNS_7290843938334 $T=340315 71115 1 0 $X=338805 $Y=60085
X299 2 21 27 pe3_CDNS_7290843938334 $T=340315 89915 1 0 $X=338805 $Y=78885
X300 2 21 27 pe3_CDNS_7290843938334 $T=340315 108715 1 0 $X=338805 $Y=97685
X301 2 21 27 pe3_CDNS_7290843938334 $T=340315 127515 1 0 $X=338805 $Y=116485
X302 2 21 27 pe3_CDNS_7290843938334 $T=340315 146315 1 0 $X=338805 $Y=135285
X303 2 21 27 pe3_CDNS_7290843938334 $T=340315 165115 1 0 $X=338805 $Y=154085
X304 2 2 2 pe3_CDNS_7290843938334 $T=351555 71115 1 0 $X=350045 $Y=60085
X305 2 21 27 pe3_CDNS_7290843938334 $T=351555 89915 1 0 $X=350045 $Y=78885
X306 2 21 27 pe3_CDNS_7290843938334 $T=351555 108715 1 0 $X=350045 $Y=97685
X307 2 21 27 pe3_CDNS_7290843938334 $T=351555 127515 1 0 $X=350045 $Y=116485
X308 2 21 27 pe3_CDNS_7290843938334 $T=351555 146315 1 0 $X=350045 $Y=135285
X309 2 21 27 pe3_CDNS_7290843938334 $T=351555 165115 1 0 $X=350045 $Y=154085
X310 2 2 2 pe3_CDNS_7290843938334 $T=362795 71115 1 0 $X=361285 $Y=60085
X311 2 2 2 pe3_CDNS_7290843938334 $T=362795 89915 1 0 $X=361285 $Y=78885
X312 2 2 2 pe3_CDNS_7290843938334 $T=362795 108715 1 0 $X=361285 $Y=97685
X313 2 2 2 pe3_CDNS_7290843938334 $T=362795 127515 1 0 $X=361285 $Y=116485
X314 2 2 2 pe3_CDNS_7290843938334 $T=362795 146315 1 0 $X=361285 $Y=135285
X315 2 2 2 pe3_CDNS_7290843938334 $T=362795 165115 1 0 $X=361285 $Y=154085
X316 28 15 5 2 13 pe3_CDNS_7290843938335 $T=364135 36320 1 0 $X=362625 $Y=25290
X317 29 15 5 2 13 pe3_CDNS_7290843938336 $T=351800 36320 1 0 $X=350290 $Y=25290
X318 30 15 5 2 13 pe3_CDNS_7290843938337 $T=333335 36320 1 0 $X=331825 $Y=25290
X319 31 15 5 2 13 pe3_CDNS_7290843938338 $T=302570 36320 1 0 $X=301060 $Y=25290
X320 27 15 5 2 13 pe3_CDNS_7290843938339 $T=246755 36320 1 0 $X=245245 $Y=25290
X321 5 1 13 rpp1k1_3_CDNS_7290843938340 $T=190390 9160 0 0 $X=185230 $Y=8940
X322 32 15 26 2 13 pe3_CDNS_7290843938341 $T=223935 36320 1 0 $X=222425 $Y=25290
X323 26 1 13 rpp1k1_3_CDNS_7290843938342 $T=80195 9200 0 0 $X=75035 $Y=8980
X324 22 1 13 pe3_CDNS_7290843938343 $T=154675 76695 0 0 $X=153165 $Y=75665
X325 15 22 13 pe3_CDNS_7290843938343 $T=154675 98175 0 0 $X=153165 $Y=97145
X326 23 15 13 pe3_CDNS_7290843938343 $T=154675 119125 0 0 $X=153165 $Y=118095
X327 2 4 16 pe3_CDNS_7290843938344 $T=91085 67915 1 0 $X=90175 $Y=61345
X328 27 7 1 2 13 pe3_CDNS_7290843938345 $T=307075 17335 1 0 $X=305565 $Y=6305
X329 31 8 1 2 13 pe3_CDNS_7290843938345 $T=316335 17335 1 0 $X=314825 $Y=6305
X330 30 9 1 2 13 pe3_CDNS_7290843938345 $T=325595 17335 1 0 $X=324085 $Y=6305
X331 29 10 1 2 13 pe3_CDNS_7290843938345 $T=334855 17335 1 0 $X=333345 $Y=6305
X332 28 11 1 2 13 pe3_CDNS_7290843938345 $T=344115 17335 1 0 $X=342605 $Y=6305
X333 14 12 1 2 13 pe3_CDNS_7290843938345 $T=353375 17335 1 0 $X=351865 $Y=6305
X334 17 3 3 13 ne3_CDNS_7290843938346 $T=7715 59435 0 0 $X=6915 $Y=59035
X335 18 3 19 13 ne3_CDNS_7290843938346 $T=34470 59435 0 0 $X=33670 $Y=59035
X336 24 3 25 13 ne3_CDNS_7290843938346 $T=62205 59435 0 0 $X=61405 $Y=59035
X337 25 25 25 2 13 ne3i_6_CDNS_7290843938347 $T=70370 100985 0 0 $X=66310 $Y=96535
X338 25 25 25 2 13 ne3i_6_CDNS_7290843938347 $T=70370 124285 1 0 $X=66310 $Y=109715
X339 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=73770 100985 0 0 $X=69710 $Y=96535
X340 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=73770 124285 1 0 $X=69710 $Y=109715
X341 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=77170 100985 0 0 $X=73110 $Y=96535
X342 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=77170 124285 1 0 $X=73110 $Y=109715
X343 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=80570 100985 0 0 $X=76510 $Y=96535
X344 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=80570 124285 1 0 $X=76510 $Y=109715
X345 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=83970 100985 0 0 $X=79910 $Y=96535
X346 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=83970 124285 1 0 $X=79910 $Y=109715
X347 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=87370 100985 0 0 $X=83310 $Y=96535
X348 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=87370 124285 1 0 $X=83310 $Y=109715
X349 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=90770 100985 0 0 $X=86710 $Y=96535
X350 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=90770 124285 1 0 $X=86710 $Y=109715
X351 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=94170 100985 0 0 $X=90110 $Y=96535
X352 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=94170 124285 1 0 $X=90110 $Y=109715
X353 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=97570 100985 0 0 $X=93510 $Y=96535
X354 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=97570 124285 1 0 $X=93510 $Y=109715
X355 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=100970 100985 0 0 $X=96910 $Y=96535
X356 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=100970 124285 1 0 $X=96910 $Y=109715
X357 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=104370 100985 0 0 $X=100310 $Y=96535
X358 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=104370 124285 1 0 $X=100310 $Y=109715
X359 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=107770 100985 0 0 $X=103710 $Y=96535
X360 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=107770 124285 1 0 $X=103710 $Y=109715
X361 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=111170 100985 0 0 $X=107110 $Y=96535
X362 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=111170 124285 1 0 $X=107110 $Y=109715
X363 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=114570 100985 0 0 $X=110510 $Y=96535
X364 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=114570 124285 1 0 $X=110510 $Y=109715
X365 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=117970 100985 0 0 $X=113910 $Y=96535
X366 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=117970 124285 1 0 $X=113910 $Y=109715
X367 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=121370 100985 0 0 $X=117310 $Y=96535
X368 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=121370 124285 1 0 $X=117310 $Y=109715
X369 25 6 21 2 13 ne3i_6_CDNS_7290843938347 $T=124770 100985 0 0 $X=120710 $Y=96535
X370 25 26 20 2 13 ne3i_6_CDNS_7290843938347 $T=124770 124285 1 0 $X=120710 $Y=109715
X371 25 25 25 2 13 ne3i_6_CDNS_7290843938347 $T=128170 100985 0 0 $X=124110 $Y=96535
X372 25 25 25 2 13 ne3i_6_CDNS_7290843938347 $T=128170 124285 1 0 $X=124110 $Y=109715
X373 1 1 1 13 ne3_CDNS_7290843938348 $T=11530 16320 0 0 $X=10730 $Y=15920
X374 1 1 1 13 ne3_CDNS_7290843938348 $T=11530 38460 1 0 $X=10730 $Y=27890
X375 1 17 24 13 ne3_CDNS_7290843938348 $T=14770 16320 0 0 $X=13970 $Y=15920
X376 1 17 17 13 ne3_CDNS_7290843938348 $T=14770 38460 1 0 $X=13970 $Y=27890
X377 1 17 18 13 ne3_CDNS_7290843938348 $T=18010 16320 0 0 $X=17210 $Y=15920
X378 1 17 24 13 ne3_CDNS_7290843938348 $T=18010 38460 1 0 $X=17210 $Y=27890
X379 1 17 17 13 ne3_CDNS_7290843938348 $T=21250 16320 0 0 $X=20450 $Y=15920
X380 1 17 18 13 ne3_CDNS_7290843938348 $T=21250 38460 1 0 $X=20450 $Y=27890
X381 1 17 24 13 ne3_CDNS_7290843938348 $T=24490 16320 0 0 $X=23690 $Y=15920
X382 1 17 17 13 ne3_CDNS_7290843938348 $T=24490 38460 1 0 $X=23690 $Y=27890
X383 1 17 18 13 ne3_CDNS_7290843938348 $T=27730 16320 0 0 $X=26930 $Y=15920
X384 1 17 24 13 ne3_CDNS_7290843938348 $T=27730 38460 1 0 $X=26930 $Y=27890
X385 1 17 17 13 ne3_CDNS_7290843938348 $T=30970 16320 0 0 $X=30170 $Y=15920
X386 1 17 18 13 ne3_CDNS_7290843938348 $T=30970 38460 1 0 $X=30170 $Y=27890
X387 1 17 24 13 ne3_CDNS_7290843938348 $T=34210 16320 0 0 $X=33410 $Y=15920
X388 1 17 17 13 ne3_CDNS_7290843938348 $T=34210 38460 1 0 $X=33410 $Y=27890
X389 1 17 18 13 ne3_CDNS_7290843938348 $T=37450 16320 0 0 $X=36650 $Y=15920
X390 1 17 24 13 ne3_CDNS_7290843938348 $T=37450 38460 1 0 $X=36650 $Y=27890
X391 1 17 17 13 ne3_CDNS_7290843938348 $T=40690 16320 0 0 $X=39890 $Y=15920
X392 1 17 18 13 ne3_CDNS_7290843938348 $T=40690 38460 1 0 $X=39890 $Y=27890
X393 1 17 24 13 ne3_CDNS_7290843938348 $T=43930 16320 0 0 $X=43130 $Y=15920
X394 1 17 17 13 ne3_CDNS_7290843938348 $T=43930 38460 1 0 $X=43130 $Y=27890
X395 1 17 18 13 ne3_CDNS_7290843938348 $T=47170 16320 0 0 $X=46370 $Y=15920
X396 1 17 24 13 ne3_CDNS_7290843938348 $T=47170 38460 1 0 $X=46370 $Y=27890
X397 1 17 17 13 ne3_CDNS_7290843938348 $T=50410 16320 0 0 $X=49610 $Y=15920
X398 1 17 18 13 ne3_CDNS_7290843938348 $T=50410 38460 1 0 $X=49610 $Y=27890
X399 1 1 1 13 ne3_CDNS_7290843938348 $T=53650 16320 0 0 $X=52850 $Y=15920
X400 1 1 1 13 ne3_CDNS_7290843938348 $T=53650 38460 1 0 $X=52850 $Y=27890
X401 2 pe3_CDNS_7290843938349 $T=205435 52315 1 0 $X=203925 $Y=49285
X402 2 pe3_CDNS_7290843938349 $T=205435 175915 1 0 $X=203925 $Y=172885
X403 2 pe3_CDNS_7290843938349 $T=216675 52315 1 0 $X=215165 $Y=49285
X404 2 pe3_CDNS_7290843938349 $T=216675 175915 1 0 $X=215165 $Y=172885
X405 2 pe3_CDNS_7290843938349 $T=227915 52315 1 0 $X=226405 $Y=49285
X406 2 pe3_CDNS_7290843938349 $T=227915 175915 1 0 $X=226405 $Y=172885
X407 2 pe3_CDNS_7290843938349 $T=239155 52315 1 0 $X=237645 $Y=49285
X408 2 pe3_CDNS_7290843938349 $T=239155 175915 1 0 $X=237645 $Y=172885
X409 2 pe3_CDNS_7290843938349 $T=250395 52315 1 0 $X=248885 $Y=49285
X410 2 pe3_CDNS_7290843938349 $T=250395 175915 1 0 $X=248885 $Y=172885
X411 2 pe3_CDNS_7290843938349 $T=261635 52315 1 0 $X=260125 $Y=49285
X412 2 pe3_CDNS_7290843938349 $T=261635 175915 1 0 $X=260125 $Y=172885
X413 2 pe3_CDNS_7290843938349 $T=272875 52315 1 0 $X=271365 $Y=49285
X414 2 pe3_CDNS_7290843938349 $T=272875 175915 1 0 $X=271365 $Y=172885
X415 2 pe3_CDNS_7290843938349 $T=284115 52315 1 0 $X=282605 $Y=49285
X416 2 pe3_CDNS_7290843938349 $T=284115 175915 1 0 $X=282605 $Y=172885
X417 2 pe3_CDNS_7290843938349 $T=295355 52315 1 0 $X=293845 $Y=49285
X418 2 pe3_CDNS_7290843938349 $T=295355 175915 1 0 $X=293845 $Y=172885
X419 2 pe3_CDNS_7290843938349 $T=306595 52315 1 0 $X=305085 $Y=49285
X420 2 pe3_CDNS_7290843938349 $T=306595 175915 1 0 $X=305085 $Y=172885
X421 2 pe3_CDNS_7290843938349 $T=317835 52315 1 0 $X=316325 $Y=49285
X422 2 pe3_CDNS_7290843938349 $T=317835 175915 1 0 $X=316325 $Y=172885
X423 2 pe3_CDNS_7290843938349 $T=329075 52315 1 0 $X=327565 $Y=49285
X424 2 pe3_CDNS_7290843938349 $T=329075 175915 1 0 $X=327565 $Y=172885
X425 2 pe3_CDNS_7290843938349 $T=340315 52315 1 0 $X=338805 $Y=49285
X426 2 pe3_CDNS_7290843938349 $T=340315 175915 1 0 $X=338805 $Y=172885
X427 2 pe3_CDNS_7290843938349 $T=351555 52315 1 0 $X=350045 $Y=49285
X428 2 pe3_CDNS_7290843938349 $T=351555 175915 1 0 $X=350045 $Y=172885
X429 2 pe3_CDNS_7290843938349 $T=362795 52315 1 0 $X=361285 $Y=49285
X430 2 pe3_CDNS_7290843938349 $T=362795 175915 1 0 $X=361285 $Y=172885
X431 1 16 17 13 ne3_CDNS_7290843938350 $T=96785 56345 0 0 $X=95985 $Y=55765
X432 1 16 5 13 ne3_CDNS_7290843938350 $T=102390 56345 0 0 $X=101590 $Y=55765
X1265 2 2 20 21 20 21 2 MASCO__A165 $T=54830 160530 0 0 $X=54830 $Y=160530
X1266 2 20 20 21 20 21 20 MASCO__A165 $T=99790 160530 0 0 $X=99790 $Y=160530
X1267 2 2 21 27 31 31 2 MASCO__A165 $T=203925 60085 0 0 $X=203925 $Y=60085
X1268 2 2 21 27 31 30 2 MASCO__A165 $T=203925 78885 0 0 $X=203925 $Y=78885
X1269 2 2 21 27 31 30 2 MASCO__A165 $T=203925 97685 0 0 $X=203925 $Y=97685
X1270 2 2 21 27 31 30 2 MASCO__A165 $T=203925 116485 0 0 $X=203925 $Y=116485
X1271 2 2 21 27 31 30 2 MASCO__A165 $T=203925 135285 0 0 $X=203925 $Y=135285
X1272 2 2 21 27 27 27 2 MASCO__A165 $T=203925 154085 0 0 $X=203925 $Y=154085
X1273 2 31 21 31 32 27 21 MASCO__A165 $T=248885 60085 0 0 $X=248885 $Y=60085
X1274 2 32 21 29 29 32 21 MASCO__A165 $T=248885 78885 0 0 $X=248885 $Y=78885
X1275 2 28 21 32 14 32 21 MASCO__A165 $T=248885 97685 0 0 $X=248885 $Y=97685
X1276 2 32 21 28 32 30 21 MASCO__A165 $T=248885 116485 0 0 $X=248885 $Y=116485
X1277 2 32 21 29 29 32 21 MASCO__A165 $T=248885 135285 0 0 $X=248885 $Y=135285
X1278 2 27 21 27 31 31 21 MASCO__A165 $T=248885 154085 0 0 $X=248885 $Y=154085
X1279 2 27 2 2 2 2 21 MASCO__A165 $T=293845 60085 0 0 $X=293845 $Y=60085
X1280 2 30 21 31 27 27 21 MASCO__A165 $T=293845 78885 0 0 $X=293845 $Y=78885
X1281 2 30 21 31 27 27 21 MASCO__A165 $T=293845 97685 0 0 $X=293845 $Y=97685
X1282 2 31 21 31 27 27 21 MASCO__A165 $T=293845 116485 0 0 $X=293845 $Y=116485
X1283 2 30 21 31 27 27 21 MASCO__A165 $T=293845 135285 0 0 $X=293845 $Y=135285
X1284 2 31 21 32 27 27 21 MASCO__A165 $T=293845 154085 0 0 $X=293845 $Y=154085
D0 13 2 p_dnw AREA=7.95604e-10 PJ=0.00014876 perimeter=0.00014876 $X=8500 $Y=140710 $dt=12
D1 13 2 p_dnw AREA=2.14716e-09 PJ=0.0003306 perimeter=0.0003306 $X=48630 $Y=140710 $dt=12
D2 13 2 p_dnw AREA=3.11448e-11 PJ=3.188e-05 perimeter=3.188e-05 $X=88435 $Y=59745 $dt=12
D3 13 22 p_dnw AREA=1.97548e-10 PJ=8.944e-05 perimeter=8.944e-05 $X=151005 $Y=72505 $dt=12
D4 13 15 p_dnw AREA=1.97548e-10 PJ=8.944e-05 perimeter=8.944e-05 $X=151005 $Y=93985 $dt=12
D5 13 23 p_dnw AREA=1.97548e-10 PJ=8.944e-05 perimeter=8.944e-05 $X=151005 $Y=114935 $dt=12
D6 13 2 p_dnw AREA=1.47356e-08 PJ=0.0006944 perimeter=0.0006944 $X=181765 $Y=46865 $dt=12
D7 13 2 p_dnw AREA=1.65707e-09 PJ=0.00035483 perimeter=0.00035483 $X=220785 $Y=22870 $dt=12
D8 13 2 p_dnw AREA=6.02548e-10 PJ=0.00014223 perimeter=0.00014223 $X=303405 $Y=4665 $dt=12
D9 13 2 p_ddnw AREA=1.72778e-09 PJ=0.0002104 perimeter=0.0002104 $X=65040 $Y=95265 $dt=15
D10 25 2 p_dipdnwmv AREA=9.7703e-10 PJ=0.0001796 perimeter=0.0001796 $X=68890 $Y=99115 $dt=19
D11 13 2 p_dnw3 AREA=2.92576e-10 PJ=0 perimeter=0 $X=14200 $Y=147550 $dt=36
D12 13 2 p_dnw3 AREA=2.92576e-10 PJ=0 perimeter=0 $X=14200 $Y=160530 $dt=36
D13 13 2 p_dnw3 AREA=1.37701e-09 PJ=0 perimeter=0 $X=54830 $Y=147550 $dt=36
D14 13 2 p_dnw3 AREA=1.37701e-09 PJ=0 perimeter=0 $X=54830 $Y=160530 $dt=36
D15 13 2 p_dnw3 AREA=2.67592e-11 PJ=0 perimeter=0 $X=89575 $Y=60885 $dt=36
D16 13 2 p_dnw3 AREA=6.91743e-10 PJ=0 perimeter=0 $X=203925 $Y=49285 $dt=36
D17 13 2 p_dnw3 AREA=2.05478e-09 PJ=0 perimeter=0 $X=203925 $Y=60085 $dt=36
D18 13 2 p_dnw3 AREA=2.05478e-09 PJ=0 perimeter=0 $X=203925 $Y=78885 $dt=36
D19 13 2 p_dnw3 AREA=2.05478e-09 PJ=0 perimeter=0 $X=203925 $Y=97685 $dt=36
D20 13 2 p_dnw3 AREA=2.05478e-09 PJ=0 perimeter=0 $X=203925 $Y=116485 $dt=36
D21 13 2 p_dnw3 AREA=2.05478e-09 PJ=0 perimeter=0 $X=203925 $Y=135285 $dt=36
D22 13 2 p_dnw3 AREA=2.05478e-09 PJ=0 perimeter=0 $X=203925 $Y=154085 $dt=36
D23 13 2 p_dnw3 AREA=6.91743e-10 PJ=0 perimeter=0 $X=203925 $Y=172885 $dt=36
D24 13 2 p_dnw3 AREA=4.84812e-11 PJ=0 perimeter=0 $X=372000 $Y=25290 $dt=36
.ends dac6b_amp_n2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pulse_generator                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pulse_generator 1 2 3 4 5 6 7 8 9 10
+ 11 12 13 14 15 16 17 18
*.DEVICECLIMB
** N=20 EP=18 FDC=593
X1 1 6 4 14 13 20 17 2 15 16
+ 18 current_source_gm_10_en_r $T=412080 18790 0 0 $X=416015 $Y=22610
X2 1 6 2 mosvc3_CDNS_7290843938332 $T=21090 101820 0 0 $X=20290 $Y=101390
X3 1 6 2 mosvc3_CDNS_7290843938332 $T=21090 154080 1 0 $X=20290 $Y=128460
X4 1 6 2 mosvc3_CDNS_7290843938332 $T=44090 101820 0 0 $X=43290 $Y=101390
X5 1 6 2 mosvc3_CDNS_7290843938332 $T=44090 154080 1 0 $X=43290 $Y=128460
X6 1 6 2 mosvc3_CDNS_7290843938333 $T=422175 183935 0 0 $X=421375 $Y=183505
X7 1 6 2 mosvc3_CDNS_7290843938333 $T=445175 183935 0 0 $X=444375 $Y=183505
X8 1 6 2 mosvc3_CDNS_7290843938333 $T=468175 183935 0 0 $X=467375 $Y=183505
X9 1 6 2 mosvc3_CDNS_7290843938333 $T=491175 183935 0 0 $X=490375 $Y=183505
X10 1 6 2 mosvc3_CDNS_7290843938333 $T=514175 183935 0 0 $X=513375 $Y=183505
X11 1 6 2 mosvc3_CDNS_7290843938333 $T=537175 183935 0 0 $X=536375 $Y=183505
X12 1 6 2 mosvc3_CDNS_7290843938333 $T=560175 183935 0 0 $X=559375 $Y=183505
X13 1 6 2 mosvc3_CDNS_7290843938333 $T=583175 183935 0 0 $X=582375 $Y=183505
X14 1 6 5 4 20 3 7 8 9 10
+ 11 12 2 dac6b_amp_n2 $T=14140 23390 0 0 $X=16780 $Y=24625
.ends pulse_generator

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938351                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938351 1 2 3 4
** N=4 EP=4 FDC=1
M0 3 2 1 4 ne3 L=5e-06 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=3
.ends ne3_CDNS_7290843938351

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938352                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938352 1 2 3 4 5
** N=5 EP=5 FDC=13
M0 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=1540 $Y=0 $dt=4
M2 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=3080 $Y=0 $dt=4
M3 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=4620 $Y=0 $dt=4
M4 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=6160 $Y=0 $dt=4
M5 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=7700 $Y=0 $dt=4
M6 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=9240 $Y=0 $dt=4
M7 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=10780 $Y=0 $dt=4
M8 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=12320 $Y=0 $dt=4
M9 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=13860 $Y=0 $dt=4
M10 3 2 1 4 pe3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=15400 $Y=0 $dt=4
M11 1 2 3 4 pe3 L=1e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=16940 $Y=0 $dt=4
D12 5 4 p_dnw3 AREA=2.52778e-10 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938352

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938353                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938353 1 2 3 4
** N=4 EP=4 FDC=3
M0 2 2 1 3 pe3 L=2e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 2 3 pe3 L=2e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=2540 $Y=0 $dt=4
D2 4 3 p_dnw3 AREA=9.11736e-11 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938353

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938354                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938354 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.0005141 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938354

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938357                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938357 1 2 3
*.DEVICECLIMB
** N=4 EP=3 FDC=1
M0 3 2 1 1 pe3 L=2e-06 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
.ends pe3_CDNS_7290843938357

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ref_bias                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ref_bias 1 2 3 4 5 6 7 8
** N=19 EP=8 FDC=187
X246 2 2 2 pe3_CDNS_7290843938334 $T=12010 172320 0 0 $X=10500 $Y=171290
X247 2 2 2 pe3_CDNS_7290843938334 $T=12010 190000 0 0 $X=10500 $Y=188970
X248 2 17 17 pe3_CDNS_7290843938334 $T=23250 172320 0 0 $X=21740 $Y=171290
X249 2 17 18 pe3_CDNS_7290843938334 $T=23250 190000 0 0 $X=21740 $Y=188970
X250 2 17 18 pe3_CDNS_7290843938334 $T=34490 172320 0 0 $X=32980 $Y=171290
X251 2 17 17 pe3_CDNS_7290843938334 $T=34490 190000 0 0 $X=32980 $Y=188970
X252 2 17 17 pe3_CDNS_7290843938334 $T=45730 172320 0 0 $X=44220 $Y=171290
X253 2 17 18 pe3_CDNS_7290843938334 $T=45730 190000 0 0 $X=44220 $Y=188970
X254 2 17 18 pe3_CDNS_7290843938334 $T=56970 172320 0 0 $X=55460 $Y=171290
X255 2 17 17 pe3_CDNS_7290843938334 $T=56970 190000 0 0 $X=55460 $Y=188970
X256 2 17 17 pe3_CDNS_7290843938334 $T=68210 172320 0 0 $X=66700 $Y=171290
X257 2 17 18 pe3_CDNS_7290843938334 $T=68210 190000 0 0 $X=66700 $Y=188970
X258 2 17 18 pe3_CDNS_7290843938334 $T=79450 172320 0 0 $X=77940 $Y=171290
X259 2 17 17 pe3_CDNS_7290843938334 $T=79450 190000 0 0 $X=77940 $Y=188970
X260 2 17 17 pe3_CDNS_7290843938334 $T=90690 172320 0 0 $X=89180 $Y=171290
X261 2 17 18 pe3_CDNS_7290843938334 $T=90690 190000 0 0 $X=89180 $Y=188970
X262 2 17 18 pe3_CDNS_7290843938334 $T=101930 172320 0 0 $X=100420 $Y=171290
X263 2 17 17 pe3_CDNS_7290843938334 $T=101930 190000 0 0 $X=100420 $Y=188970
X264 2 2 2 pe3_CDNS_7290843938334 $T=113170 172320 0 0 $X=111660 $Y=171290
X265 2 2 2 pe3_CDNS_7290843938334 $T=113170 190000 0 0 $X=111660 $Y=188970
X266 15 13 6 2 8 pe3_CDNS_7290843938341 $T=189280 150320 0 0 $X=187770 $Y=149290
X267 16 13 5 2 8 pe3_CDNS_7290843938341 $T=213190 150320 0 0 $X=211680 $Y=149290
X268 9 3 3 8 ne3_CDNS_7290843938346 $T=17545 54415 0 0 $X=16745 $Y=54015
X269 10 3 11 8 ne3_CDNS_7290843938346 $T=42480 54195 0 0 $X=41680 $Y=53795
X270 11 11 11 2 8 ne3i_6_CDNS_7290843938347 $T=13390 118480 0 0 $X=9330 $Y=114030
X271 11 11 11 2 8 ne3i_6_CDNS_7290843938347 $T=13390 143280 1 0 $X=9330 $Y=128710
X272 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=16790 118480 0 0 $X=12730 $Y=114030
X273 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=16790 143280 1 0 $X=12730 $Y=128710
X274 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=20190 118480 0 0 $X=16130 $Y=114030
X275 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=20190 143280 1 0 $X=16130 $Y=128710
X276 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=23590 118480 0 0 $X=19530 $Y=114030
X277 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=23590 143280 1 0 $X=19530 $Y=128710
X278 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=26990 118480 0 0 $X=22930 $Y=114030
X279 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=26990 143280 1 0 $X=22930 $Y=128710
X280 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=30390 118480 0 0 $X=26330 $Y=114030
X281 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=30390 143280 1 0 $X=26330 $Y=128710
X282 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=33790 118480 0 0 $X=29730 $Y=114030
X283 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=33790 143280 1 0 $X=29730 $Y=128710
X284 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=37190 118480 0 0 $X=33130 $Y=114030
X285 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=37190 143280 1 0 $X=33130 $Y=128710
X286 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=40590 118480 0 0 $X=36530 $Y=114030
X287 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=40590 143280 1 0 $X=36530 $Y=128710
X288 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=43990 118480 0 0 $X=39930 $Y=114030
X289 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=43990 143280 1 0 $X=39930 $Y=128710
X290 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=47390 118480 0 0 $X=43330 $Y=114030
X291 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=47390 143280 1 0 $X=43330 $Y=128710
X292 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=50790 118480 0 0 $X=46730 $Y=114030
X293 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=50790 143280 1 0 $X=46730 $Y=128710
X294 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=54190 118480 0 0 $X=50130 $Y=114030
X295 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=54190 143280 1 0 $X=50130 $Y=128710
X296 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=57590 118480 0 0 $X=53530 $Y=114030
X297 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=57590 143280 1 0 $X=53530 $Y=128710
X298 11 7 18 2 8 ne3i_6_CDNS_7290843938347 $T=60990 118480 0 0 $X=56930 $Y=114030
X299 11 4 17 2 8 ne3i_6_CDNS_7290843938347 $T=60990 143280 1 0 $X=56930 $Y=128710
X300 11 11 11 2 8 ne3i_6_CDNS_7290843938347 $T=64390 118480 0 0 $X=60330 $Y=114030
X301 11 11 11 2 8 ne3i_6_CDNS_7290843938347 $T=64390 143280 1 0 $X=60330 $Y=128710
X464 1 1 1 8 ne3_CDNS_7290843938351 $T=17980 14080 0 0 $X=17180 $Y=13680
X465 1 1 1 8 ne3_CDNS_7290843938351 $T=17980 30170 0 0 $X=17180 $Y=29770
X466 1 9 10 8 ne3_CDNS_7290843938351 $T=24220 14080 0 0 $X=23420 $Y=13680
X467 1 9 9 8 ne3_CDNS_7290843938351 $T=24220 30170 0 0 $X=23420 $Y=29770
X468 1 9 9 8 ne3_CDNS_7290843938351 $T=30460 14080 0 0 $X=29660 $Y=13680
X469 1 9 10 8 ne3_CDNS_7290843938351 $T=30460 30170 0 0 $X=29660 $Y=29770
X470 1 9 13 8 ne3_CDNS_7290843938351 $T=36700 14080 0 0 $X=35900 $Y=13680
X471 1 9 9 8 ne3_CDNS_7290843938351 $T=36700 30170 0 0 $X=35900 $Y=29770
X472 1 9 9 8 ne3_CDNS_7290843938351 $T=42940 14080 0 0 $X=42140 $Y=13680
X473 1 9 10 8 ne3_CDNS_7290843938351 $T=42940 30170 0 0 $X=42140 $Y=29770
X474 1 9 10 8 ne3_CDNS_7290843938351 $T=49180 14080 0 0 $X=48380 $Y=13680
X475 1 1 1 8 ne3_CDNS_7290843938351 $T=49180 30170 0 0 $X=48380 $Y=29770
X476 1 1 1 8 ne3_CDNS_7290843938351 $T=55420 14080 0 0 $X=54620 $Y=13680
X477 1 1 1 8 ne3_CDNS_7290843938351 $T=55420 30170 0 0 $X=54620 $Y=29770
X478 14 13 4 2 8 pe3_CDNS_7290843938352 $T=162340 150320 0 0 $X=160830 $Y=149290
X479 2 12 2 8 pe3_CDNS_7290843938353 $T=138060 190125 0 0 $X=136550 $Y=189095
X480 12 13 2 8 pe3_CDNS_7290843938353 $T=147620 190125 0 0 $X=146110 $Y=189095
X481 4 19 8 rpp1k1_3_CDNS_7290843938354 $T=87870 117335 0 0 $X=82710 $Y=117115
X482 2 2 2 pe3_CDNS_7290843938357 $T=165675 175935 0 0 $X=164165 $Y=174905
X483 2 2 2 pe3_CDNS_7290843938357 $T=165675 195955 0 0 $X=164165 $Y=194925
X484 2 18 15 pe3_CDNS_7290843938357 $T=168915 175935 0 0 $X=167405 $Y=174905
X485 2 18 16 pe3_CDNS_7290843938357 $T=168915 195955 0 0 $X=167405 $Y=194925
X486 2 18 16 pe3_CDNS_7290843938357 $T=172155 175935 0 0 $X=170645 $Y=174905
X487 2 18 14 pe3_CDNS_7290843938357 $T=172155 195955 0 0 $X=170645 $Y=194925
X488 2 18 14 pe3_CDNS_7290843938357 $T=175395 175935 0 0 $X=173885 $Y=174905
X489 2 18 15 pe3_CDNS_7290843938357 $T=175395 195955 0 0 $X=173885 $Y=194925
X490 2 18 15 pe3_CDNS_7290843938357 $T=178635 175935 0 0 $X=177125 $Y=174905
X491 2 18 16 pe3_CDNS_7290843938357 $T=178635 195955 0 0 $X=177125 $Y=194925
X492 2 18 14 pe3_CDNS_7290843938357 $T=181875 175935 0 0 $X=180365 $Y=174905
X493 2 18 16 pe3_CDNS_7290843938357 $T=181875 195955 0 0 $X=180365 $Y=194925
X494 2 18 16 pe3_CDNS_7290843938357 $T=185115 175935 0 0 $X=183605 $Y=174905
X495 2 18 14 pe3_CDNS_7290843938357 $T=185115 195955 0 0 $X=183605 $Y=194925
X496 2 18 14 pe3_CDNS_7290843938357 $T=188355 175935 0 0 $X=186845 $Y=174905
X497 2 18 15 pe3_CDNS_7290843938357 $T=188355 195955 0 0 $X=186845 $Y=194925
X498 2 18 15 pe3_CDNS_7290843938357 $T=191595 175935 0 0 $X=190085 $Y=174905
X499 2 18 14 pe3_CDNS_7290843938357 $T=191595 195955 0 0 $X=190085 $Y=194925
X500 2 18 14 pe3_CDNS_7290843938357 $T=194835 175935 0 0 $X=193325 $Y=174905
X501 2 18 16 pe3_CDNS_7290843938357 $T=194835 195955 0 0 $X=193325 $Y=194925
X502 2 18 16 pe3_CDNS_7290843938357 $T=198075 175935 0 0 $X=196565 $Y=174905
X503 2 18 14 pe3_CDNS_7290843938357 $T=198075 195955 0 0 $X=196565 $Y=194925
X504 2 18 14 pe3_CDNS_7290843938357 $T=201315 175935 0 0 $X=199805 $Y=174905
X505 2 18 15 pe3_CDNS_7290843938357 $T=201315 195955 0 0 $X=199805 $Y=194925
X506 2 18 15 pe3_CDNS_7290843938357 $T=204555 175935 0 0 $X=203045 $Y=174905
X507 2 18 14 pe3_CDNS_7290843938357 $T=204555 195955 0 0 $X=203045 $Y=194925
X508 2 18 15 pe3_CDNS_7290843938357 $T=207795 175935 0 0 $X=206285 $Y=174905
X509 2 18 16 pe3_CDNS_7290843938357 $T=207795 195955 0 0 $X=206285 $Y=194925
X510 2 18 16 pe3_CDNS_7290843938357 $T=211035 175935 0 0 $X=209525 $Y=174905
X511 2 18 14 pe3_CDNS_7290843938357 $T=211035 195955 0 0 $X=209525 $Y=194925
X512 2 18 14 pe3_CDNS_7290843938357 $T=214275 175935 0 0 $X=212765 $Y=174905
X513 2 18 15 pe3_CDNS_7290843938357 $T=214275 195955 0 0 $X=212765 $Y=194925
X514 2 18 15 pe3_CDNS_7290843938357 $T=217515 175935 0 0 $X=216005 $Y=174905
X515 2 18 16 pe3_CDNS_7290843938357 $T=217515 195955 0 0 $X=216005 $Y=194925
X516 2 2 2 pe3_CDNS_7290843938357 $T=220755 175935 0 0 $X=219245 $Y=174905
X517 2 2 2 pe3_CDNS_7290843938357 $T=220755 195955 0 0 $X=219245 $Y=194925
X672 5 1 8 MOSVC3 w=3e-05 l=3e-05 $X=85530 $Y=8110 $dt=8
X673 5 1 8 MOSVC3 w=3e-05 l=3e-05 $X=85530 $Y=39350 $dt=8
X674 5 1 8 MOSVC3 w=3e-05 l=3e-05 $X=85530 $Y=70590 $dt=8
X675 6 1 8 MOSVC3 w=3e-05 l=3e-05 $X=122495 $Y=8050 $dt=8
X676 6 1 8 MOSVC3 w=3e-05 l=3e-05 $X=122495 $Y=39290 $dt=8
X677 6 1 8 MOSVC3 w=3e-05 l=3e-05 $X=122495 $Y=70530 $dt=8
D6 8 2 p_dnw AREA=2.36318e-09 PJ=0.00033402 perimeter=0.00033402 $X=4385 $Y=163650 $dt=12
D7 8 2 p_dnw AREA=2.57209e-10 PJ=8.388e-05 perimeter=8.388e-05 $X=134410 $Y=183535 $dt=12
D8 8 2 p_dnw AREA=1.81014e-09 PJ=0.00023539 perimeter=0.00023539 $X=158410 $Y=166295 $dt=12
D9 8 2 p_dnw AREA=8.15582e-10 PJ=0.0001871 perimeter=0.0001871 $X=158690 $Y=143730 $dt=12
D10 8 2 p_dnw AREA=9.45702e-09 PJ=0.00040696 perimeter=0.00040696 $X=159475 $Y=6005 $dt=12
D11 8 2 p_ddnw AREA=1.66704e-09 PJ=0.0001998 perimeter=0.0001998 $X=8060 $Y=112760 $dt=15
D12 11 2 p_dipdnwmv AREA=9.57098e-10 PJ=0.000169 perimeter=0.000169 $X=11910 $Y=116610 $dt=19
D13 8 2 p_dnw3 AREA=1.37701e-09 PJ=0 perimeter=0 $X=10500 $Y=171290 $dt=36
D14 8 2 p_dnw3 AREA=1.37701e-09 PJ=0 perimeter=0 $X=10500 $Y=188970 $dt=36
D15 8 1 p_dnw3 AREA=2.03309e-10 PJ=0.00024988 perimeter=0.00024988 $X=85100 $Y=7310 $dt=36
D16 8 1 p_dnw3 AREA=2.03309e-10 PJ=0.00024988 perimeter=0.00024988 $X=122065 $Y=7250 $dt=36
D17 8 2 p_dnw3 AREA=7.24806e-10 PJ=0 perimeter=0 $X=164165 $Y=174905 $dt=36
D18 8 2 p_dnw3 AREA=7.24806e-10 PJ=0 perimeter=0 $X=164165 $Y=194925 $dt=36
C19 18 19 area=9e-10 perimeter=0.00012 $[cmm5t] $X=161615 $Y=8145 $dt=43
C20 18 19 area=9e-10 perimeter=0.00012 $[cmm5t] $X=161615 $Y=39745 $dt=43
C21 18 19 area=9e-10 perimeter=0.00012 $[cmm5t] $X=161615 $Y=71345 $dt=43
C22 18 19 area=9e-10 perimeter=0.00012 $[cmm5t] $X=161615 $Y=102945 $dt=43
C23 18 19 area=9e-10 perimeter=0.00012 $[cmm5t] $X=196615 $Y=8145 $dt=43
C24 18 19 area=9e-10 perimeter=0.00012 $[cmm5t] $X=196615 $Y=39745 $dt=43
C25 18 19 area=9e-10 perimeter=0.00012 $[cmm5t] $X=196615 $Y=71345 $dt=43
C26 18 19 area=9e-10 perimeter=0.00012 $[cmm5t] $X=196615 $Y=102945 $dt=43
.ends ref_bias

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938358                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938358 1 2 3 4
** N=4 EP=4 FDC=4
M0 3 2 1 4 ne3 L=1e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=3
M1 1 2 3 4 ne3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=1540 $Y=0 $dt=3
M2 3 2 1 4 ne3 L=1e-06 W=1e-05 AD=2.7e-12 AS=2.7e-12 PD=1.054e-05 PS=1.054e-05 $X=3080 $Y=0 $dt=3
M3 1 2 3 4 ne3 L=1e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=4620 $Y=0 $dt=3
.ends ne3_CDNS_7290843938358

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938359                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938359 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.0005215 W=8e-06 $[rpp1k1_3] $SUB=3 $X=-8220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938359

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938360                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938360 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.00082283 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938360

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938361                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938361 1 2 3 4
** N=4 EP=4 FDC=1
M0 3 2 1 4 ne3 L=1e-06 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=3
.ends ne3_CDNS_7290843938361

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938362                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938362 1 2 3 4 5
** N=5 EP=5 FDC=2
M0 3 2 1 4 pe3 L=5e-06 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
D1 5 4 p_dnw3 AREA=9.67212e-11 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938362

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938363                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938363 1 2 3
** N=3 EP=3 FDC=1
M0 2 2 1 3 ne3 L=2e-06 W=1e-06 AD=4.8e-13 AS=4.8e-13 PD=2.96e-06 PS=2.96e-06 $X=0 $Y=0 $dt=3
.ends ne3_CDNS_7290843938363

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938364                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938364 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.00082283 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938364

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: bandgap_su                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt bandgap_su 1 2 3 4 5
** N=25 EP=5 FDC=165
X0 2 2 2 2 pe3_CDNS_7290843938317 $T=10660 106140 0 0 $X=9150 $Y=105110
X1 2 2 2 2 pe3_CDNS_7290843938317 $T=10660 129120 1 0 $X=9150 $Y=118090
X2 2 6 4 2 pe3_CDNS_7290843938317 $T=12900 106140 0 0 $X=11390 $Y=105110
X3 2 6 4 2 pe3_CDNS_7290843938317 $T=12900 129120 1 0 $X=11390 $Y=118090
X4 2 6 4 2 pe3_CDNS_7290843938317 $T=15140 106140 0 0 $X=13630 $Y=105110
X5 2 6 4 2 pe3_CDNS_7290843938317 $T=15140 129120 1 0 $X=13630 $Y=118090
X6 2 6 7 2 pe3_CDNS_7290843938317 $T=17380 106140 0 0 $X=15870 $Y=105110
X7 2 6 6 2 pe3_CDNS_7290843938317 $T=17380 129120 1 0 $X=15870 $Y=118090
X8 2 6 4 2 pe3_CDNS_7290843938317 $T=19620 106140 0 0 $X=18110 $Y=105110
X9 2 6 4 2 pe3_CDNS_7290843938317 $T=19620 129120 1 0 $X=18110 $Y=118090
X10 2 6 4 2 pe3_CDNS_7290843938317 $T=21860 106140 0 0 $X=20350 $Y=105110
X11 2 6 4 2 pe3_CDNS_7290843938317 $T=21860 129120 1 0 $X=20350 $Y=118090
X12 2 6 6 2 pe3_CDNS_7290843938317 $T=24100 106140 0 0 $X=22590 $Y=105110
X13 2 6 7 2 pe3_CDNS_7290843938317 $T=24100 129120 1 0 $X=22590 $Y=118090
X14 2 6 7 2 pe3_CDNS_7290843938317 $T=26340 106140 0 0 $X=24830 $Y=105110
X15 2 6 6 2 pe3_CDNS_7290843938317 $T=26340 129120 1 0 $X=24830 $Y=118090
X16 2 6 4 2 pe3_CDNS_7290843938317 $T=28580 106140 0 0 $X=27070 $Y=105110
X17 2 6 4 2 pe3_CDNS_7290843938317 $T=28580 129120 1 0 $X=27070 $Y=118090
X18 2 6 4 2 pe3_CDNS_7290843938317 $T=30820 106140 0 0 $X=29310 $Y=105110
X19 2 6 4 2 pe3_CDNS_7290843938317 $T=30820 129120 1 0 $X=29310 $Y=118090
X20 2 6 6 2 pe3_CDNS_7290843938317 $T=33060 106140 0 0 $X=31550 $Y=105110
X21 2 6 7 2 pe3_CDNS_7290843938317 $T=33060 129120 1 0 $X=31550 $Y=118090
X22 2 6 4 2 pe3_CDNS_7290843938317 $T=35300 106140 0 0 $X=33790 $Y=105110
X23 2 6 4 2 pe3_CDNS_7290843938317 $T=35300 129120 1 0 $X=33790 $Y=118090
X24 2 6 4 2 pe3_CDNS_7290843938317 $T=37540 106140 0 0 $X=36030 $Y=105110
X25 2 6 4 2 pe3_CDNS_7290843938317 $T=37540 129120 1 0 $X=36030 $Y=118090
X26 2 2 2 2 pe3_CDNS_7290843938317 $T=39780 106140 0 0 $X=38270 $Y=105110
X27 2 2 2 2 pe3_CDNS_7290843938317 $T=39780 129120 1 0 $X=38270 $Y=118090
X28 8 8 8 2 pe3_CDNS_7290843938322 $T=43105 60145 0 0 $X=41595 $Y=59115
X29 8 8 8 2 pe3_CDNS_7290843938322 $T=43105 83765 1 0 $X=41595 $Y=72735
X30 8 9 10 2 pe3_CDNS_7290843938322 $T=49345 60145 0 0 $X=47835 $Y=59115
X31 8 11 12 2 pe3_CDNS_7290843938322 $T=49345 83765 1 0 $X=47835 $Y=72735
X32 8 11 12 2 pe3_CDNS_7290843938322 $T=55585 60145 0 0 $X=54075 $Y=59115
X33 8 9 10 2 pe3_CDNS_7290843938322 $T=55585 83765 1 0 $X=54075 $Y=72735
X34 2 13 13 2 pe3_CDNS_7290843938322 $T=59655 129400 1 0 $X=58145 $Y=118370
X35 8 9 10 2 pe3_CDNS_7290843938322 $T=61825 60145 0 0 $X=60315 $Y=59115
X36 8 11 12 2 pe3_CDNS_7290843938322 $T=61825 83765 1 0 $X=60315 $Y=72735
X37 2 13 9 2 pe3_CDNS_7290843938322 $T=65895 129400 1 0 $X=64385 $Y=118370
X38 8 11 12 2 pe3_CDNS_7290843938322 $T=68065 60145 0 0 $X=66555 $Y=59115
X39 8 9 10 2 pe3_CDNS_7290843938322 $T=68065 83765 1 0 $X=66555 $Y=72735
X40 8 9 10 2 pe3_CDNS_7290843938322 $T=74305 60145 0 0 $X=72795 $Y=59115
X41 8 11 12 2 pe3_CDNS_7290843938322 $T=74305 83765 1 0 $X=72795 $Y=72735
X42 2 14 14 2 pe3_CDNS_7290843938322 $T=79075 125320 0 0 $X=77565 $Y=124290
X43 8 11 12 2 pe3_CDNS_7290843938322 $T=80545 60145 0 0 $X=79035 $Y=59115
X44 8 9 10 2 pe3_CDNS_7290843938322 $T=80545 83765 1 0 $X=79035 $Y=72735
X45 2 14 15 2 pe3_CDNS_7290843938322 $T=85315 125320 0 0 $X=83805 $Y=124290
X46 8 9 10 2 pe3_CDNS_7290843938322 $T=86785 60145 0 0 $X=85275 $Y=59115
X47 8 11 12 2 pe3_CDNS_7290843938322 $T=86785 83765 1 0 $X=85275 $Y=72735
X48 8 11 12 2 pe3_CDNS_7290843938322 $T=93025 60145 0 0 $X=91515 $Y=59115
X49 8 9 10 2 pe3_CDNS_7290843938322 $T=93025 83765 1 0 $X=91515 $Y=72735
X50 8 8 8 2 pe3_CDNS_7290843938322 $T=99265 60145 0 0 $X=97755 $Y=59115
X51 8 8 8 2 pe3_CDNS_7290843938322 $T=99265 83765 1 0 $X=97755 $Y=72735
X331 6 17 17 2 5 pe3_CDNS_7290843938336 $T=9635 78185 0 0 $X=8125 $Y=77155
X332 7 17 8 2 5 pe3_CDNS_7290843938336 $T=23440 78185 0 0 $X=21930 $Y=77155
X357 1 1 1 5 ne3_CDNS_7290843938351 $T=44780 15300 0 0 $X=43980 $Y=14900
X358 1 1 1 5 ne3_CDNS_7290843938351 $T=44780 37440 1 0 $X=43980 $Y=26870
X359 1 12 12 5 ne3_CDNS_7290843938351 $T=51020 15300 0 0 $X=50220 $Y=14900
X360 1 12 10 5 ne3_CDNS_7290843938351 $T=51020 37440 1 0 $X=50220 $Y=26870
X361 1 12 10 5 ne3_CDNS_7290843938351 $T=57260 15300 0 0 $X=56460 $Y=14900
X362 1 12 12 5 ne3_CDNS_7290843938351 $T=57260 37440 1 0 $X=56460 $Y=26870
X363 1 12 12 5 ne3_CDNS_7290843938351 $T=63500 15300 0 0 $X=62700 $Y=14900
X364 1 12 10 5 ne3_CDNS_7290843938351 $T=63500 37440 1 0 $X=62700 $Y=26870
X365 1 12 10 5 ne3_CDNS_7290843938351 $T=69740 15300 0 0 $X=68940 $Y=14900
X366 1 12 12 5 ne3_CDNS_7290843938351 $T=69740 37440 1 0 $X=68940 $Y=26870
X367 1 12 12 5 ne3_CDNS_7290843938351 $T=75980 15300 0 0 $X=75180 $Y=14900
X368 1 12 10 5 ne3_CDNS_7290843938351 $T=75980 37440 1 0 $X=75180 $Y=26870
X369 1 12 10 5 ne3_CDNS_7290843938351 $T=82220 15300 0 0 $X=81420 $Y=14900
X370 1 12 12 5 ne3_CDNS_7290843938351 $T=82220 37440 1 0 $X=81420 $Y=26870
X371 1 12 12 5 ne3_CDNS_7290843938351 $T=88460 15300 0 0 $X=87660 $Y=14900
X372 1 12 10 5 ne3_CDNS_7290843938351 $T=88460 37440 1 0 $X=87660 $Y=26870
X373 1 12 10 5 ne3_CDNS_7290843938351 $T=94700 15300 0 0 $X=93900 $Y=14900
X374 1 12 12 5 ne3_CDNS_7290843938351 $T=94700 37440 1 0 $X=93900 $Y=26870
X375 1 1 1 5 ne3_CDNS_7290843938351 $T=100940 15300 0 0 $X=100140 $Y=14900
X376 1 1 1 5 ne3_CDNS_7290843938351 $T=100940 37440 1 0 $X=100140 $Y=26870
X396 19 3 3 5 ne3_CDNS_7290843938358 $T=10345 55405 0 0 $X=9545 $Y=55005
X397 20 3 17 5 ne3_CDNS_7290843938358 $T=22730 55545 0 0 $X=21930 $Y=55145
X398 1 10 4 5 ne3_CDNS_7290843938358 $T=95790 103175 0 0 $X=94990 $Y=102775
X399 11 22 5 rpp1k1_3_CDNS_7290843938359 $T=287735 7255 1 180 $X=159445 $Y=7035
X400 4 23 5 rpp1k1_3_CDNS_7290843938360 $T=123895 47740 0 0 $X=118735 $Y=47520
X401 1 1 1 5 ne3_CDNS_7290843938361 $T=13130 16755 0 0 $X=12330 $Y=16355
X402 1 1 1 5 ne3_CDNS_7290843938361 $T=13130 38815 1 0 $X=12330 $Y=28245
X403 1 19 20 5 ne3_CDNS_7290843938361 $T=15370 16755 0 0 $X=14570 $Y=16355
X404 1 19 19 5 ne3_CDNS_7290843938361 $T=15370 38815 1 0 $X=14570 $Y=28245
X405 1 19 19 5 ne3_CDNS_7290843938361 $T=17610 16755 0 0 $X=16810 $Y=16355
X406 1 19 20 5 ne3_CDNS_7290843938361 $T=17610 38815 1 0 $X=16810 $Y=28245
X407 1 19 16 5 ne3_CDNS_7290843938361 $T=19850 16755 0 0 $X=19050 $Y=16355
X408 1 19 21 5 ne3_CDNS_7290843938361 $T=19850 38815 1 0 $X=19050 $Y=28245
X409 1 19 20 5 ne3_CDNS_7290843938361 $T=22090 16755 0 0 $X=21290 $Y=16355
X410 1 19 19 5 ne3_CDNS_7290843938361 $T=22090 38815 1 0 $X=21290 $Y=28245
X411 1 19 19 5 ne3_CDNS_7290843938361 $T=24330 16755 0 0 $X=23530 $Y=16355
X412 1 19 20 5 ne3_CDNS_7290843938361 $T=24330 38815 1 0 $X=23530 $Y=28245
X413 1 1 1 5 ne3_CDNS_7290843938361 $T=26570 16755 0 0 $X=25770 $Y=16355
X414 1 1 1 5 ne3_CDNS_7290843938361 $T=26570 38815 1 0 $X=25770 $Y=28245
X415 16 4 14 5 ne3_CDNS_7290843938361 $T=97960 125180 0 0 $X=97160 $Y=124780
X416 16 18 15 5 ne3_CDNS_7290843938361 $T=100200 125180 0 0 $X=99400 $Y=124780
X417 13 15 21 2 5 pe3_CDNS_7290843938362 $T=62750 104210 0 0 $X=61240 $Y=103180
X418 1 18 5 ne3_CDNS_7290843938363 $T=110195 126990 0 0 $X=109395 $Y=126590
X419 18 24 5 ne3_CDNS_7290843938363 $T=110195 130510 0 0 $X=109395 $Y=130110
X420 24 2 5 ne3_CDNS_7290843938363 $T=110195 134045 0 0 $X=109395 $Y=133645
X421 4 25 5 rpp1k1_3_CDNS_7290843938364 $T=123895 96235 0 0 $X=118735 $Y=96015
X422 23 11 5 rpp1k1_3_CDNS_7290843938364 $T=213685 47740 0 0 $X=208525 $Y=47520
X423 25 9 5 rpp1k1_3_CDNS_7290843938364 $T=213685 96235 0 0 $X=208525 $Y=96015
Q0 5 1 22 qpvc3 $X=302595 $Y=9520 $dt=9
Q1 5 1 22 qpvc3 $X=302595 $Y=26270 $dt=9
Q2 5 1 22 qpvc3 $X=302595 $Y=43020 $dt=9
Q3 5 1 22 qpvc3 $X=302595 $Y=59770 $dt=9
Q4 5 1 22 qpvc3 $X=302595 $Y=76520 $dt=9
Q5 5 1 22 qpvc3 $X=302595 $Y=93270 $dt=9
Q6 5 1 22 qpvc3 $X=302595 $Y=110020 $dt=9
Q7 5 1 22 qpvc3 $X=302595 $Y=126770 $dt=9
Q8 5 1 22 qpvc3 $X=319350 $Y=9520 $dt=9
Q9 5 1 22 qpvc3 $X=319350 $Y=26270 $dt=9
Q10 5 1 22 qpvc3 $X=319350 $Y=43020 $dt=9
Q11 5 1 9 qpvc3 $X=319350 $Y=59770 $dt=9
Q12 5 1 22 qpvc3 $X=319350 $Y=76520 $dt=9
Q13 5 1 22 qpvc3 $X=319350 $Y=93270 $dt=9
Q14 5 1 22 qpvc3 $X=319350 $Y=110020 $dt=9
Q15 5 1 22 qpvc3 $X=319350 $Y=126770 $dt=9
Q16 5 1 22 qpvc3 $X=336105 $Y=9520 $dt=9
Q17 5 1 22 qpvc3 $X=336105 $Y=26270 $dt=9
Q18 5 1 22 qpvc3 $X=336105 $Y=43020 $dt=9
Q19 5 1 22 qpvc3 $X=336105 $Y=59770 $dt=9
Q20 5 1 22 qpvc3 $X=336105 $Y=76520 $dt=9
Q21 5 1 22 qpvc3 $X=336105 $Y=93270 $dt=9
Q22 5 1 22 qpvc3 $X=336105 $Y=110020 $dt=9
Q23 5 1 22 qpvc3 $X=336105 $Y=126770 $dt=9
Q24 5 1 22 qpvc3 $X=352860 $Y=9520 $dt=9
Q25 5 1 22 qpvc3 $X=352860 $Y=26270 $dt=9
Q26 5 1 22 qpvc3 $X=352860 $Y=43020 $dt=9
Q27 5 1 22 qpvc3 $X=352860 $Y=59770 $dt=9
Q28 5 1 22 qpvc3 $X=352860 $Y=76520 $dt=9
Q29 5 1 22 qpvc3 $X=352860 $Y=93270 $dt=9
Q30 5 1 22 qpvc3 $X=352860 $Y=110020 $dt=9
Q31 5 1 22 qpvc3 $X=352860 $Y=126770 $dt=9
D32 5 2 p_dnw AREA=1.07147e-09 PJ=0.0001732 perimeter=0.0001732 $X=3950 $Y=96990 $dt=12
D33 5 2 p_dnw AREA=2.50005e-10 PJ=8.653e-05 perimeter=8.653e-05 $X=6985 $Y=72595 $dt=12
D34 5 2 p_dnw AREA=1.35123e-09 PJ=0.00022788 perimeter=0.00022788 $X=35895 $Y=52775 $dt=12
D35 5 2 p_dnw AREA=3.30547e-10 PJ=0.00010554 perimeter=0.00010554 $X=57005 $Y=102040 $dt=12
D36 5 2 p_dnw AREA=1.64117e-10 PJ=7.372e-05 perimeter=7.372e-05 $X=76425 $Y=117950 $dt=12
D37 5 2 p_dnw AREA=1.17512e-09 PJ=0.00013712 perimeter=0.00013712 $X=119255 $Y=7325 $dt=12
D38 5 2 p_dnw3 AREA=3.99668e-10 PJ=0 perimeter=0 $X=9150 $Y=105110 $dt=36
D39 5 2 p_dnw3 AREA=3.99668e-10 PJ=0 perimeter=0 $X=9150 $Y=118090 $dt=36
D40 5 2 p_dnw3 AREA=7.74011e-10 PJ=0 perimeter=0 $X=41595 $Y=59115 $dt=36
D41 5 2 p_dnw3 AREA=7.74011e-10 PJ=0 perimeter=0 $X=41595 $Y=72735 $dt=36
D42 5 2 p_dnw3 AREA=1.71976e-10 PJ=0 perimeter=0 $X=58145 $Y=118370 $dt=36
D43 5 2 p_dnw3 AREA=1.71976e-10 PJ=0 perimeter=0 $X=77565 $Y=124290 $dt=36
C44 10 4 area=9e-10 perimeter=0.00012 $[cmm5t] $X=121395 $Y=9465 $dt=43
.ends bandgap_su

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: mosvc3_CDNS_7290843938365                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt mosvc3_CDNS_7290843938365 1 2 3
** N=3 EP=3 FDC=2
X0 2 1 3 MOSVC3 w=2.5e-05 l=3e-05 $X=0 $Y=0 $dt=8
D1 3 1 p_dnw3 AREA=6.7176e-11 PJ=0.00011492 perimeter=0.00011492 $X=-800 $Y=-430 $dt=36
.ends mosvc3_CDNS_7290843938365

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3i_6_CDNS_7290843938366                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3i_6_CDNS_7290843938366 1 2 3 4
** N=4 EP=4 FDC=4
X0 1 3 3 1 2 4 NE3I_6 w=1e-05 l=2.5e-06 as=2.7e-12 ad=4.8e-12 ps=1.054e-05 pd=2.096e-05 $X=0 $Y=0 $dt=7
X1 3 3 1 1 2 4 NE3I_6 w=1e-05 l=2.5e-06 as=4.8e-12 ad=2.7e-12 ps=2.096e-05 pd=1.054e-05 $X=3040 $Y=0 $dt=7
D2 4 2 p_ddnw AREA=3.07331e-10 PJ=7.576e-05 perimeter=7.576e-05 $X=-6110 $Y=-4940 $dt=15
D3 1 2 p_dipdnwmv AREA=7.49452e-11 PJ=4.496e-05 perimeter=4.496e-05 $X=-2260 $Y=-1090 $dt=19
.ends ne3i_6_CDNS_7290843938366

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938367                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938367 1 2 3
** N=3 EP=3 FDC=2
M0 2 2 1 1 pe3 L=1e-05 W=2e-06 AD=9.6e-13 AS=9.6e-13 PD=4.96e-06 PS=4.96e-06 $X=0 $Y=0 $dt=4
D1 3 1 p_dnw3 AREA=4.57434e-11 PJ=3.138e-05 perimeter=3.138e-05 $X=-910 $Y=-1440 $dt=36
.ends pe3_CDNS_7290843938367

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938368                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938368 1 2 3 4
** N=4 EP=4 FDC=2
M0 3 2 1 4 ne3 L=2.5e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=3
M1 1 2 3 4 ne3 L=2.5e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=3040 $Y=0 $dt=3
.ends ne3_CDNS_7290843938368

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938369                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938369 1 2 3 4 5
** N=5 EP=5 FDC=3
M0 3 2 1 4 pe3 L=2.5e-06 W=1e-05 AD=2.7e-12 AS=4.8e-12 PD=1.054e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
M1 1 2 3 4 pe3 L=2.5e-06 W=1e-05 AD=4.8e-12 AS=2.7e-12 PD=2.096e-05 PS=1.054e-05 $X=3040 $Y=0 $dt=4
D2 5 4 p_dnw3 AREA=1.03234e-10 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938369

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938370                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938370 1 2 3 4 5
** N=5 EP=5 FDC=2
M0 3 2 1 4 pe3 L=2.5e-06 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
D1 5 4 p_dnw3 AREA=6.65712e-11 PJ=0 perimeter=0 $X=-1510 $Y=-1030 $dt=36
.ends pe3_CDNS_7290843938370

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938371                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938371 1 2 3
*.DEVICECLIMB
** N=4 EP=3 FDC=1
M0 3 2 1 1 pe3 L=2.5e-06 W=1e-05 AD=4.8e-12 AS=4.8e-12 PD=2.096e-05 PS=2.096e-05 $X=0 $Y=0 $dt=4
.ends pe3_CDNS_7290843938371

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3i_6_CDNS_7290843938372                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3i_6_CDNS_7290843938372 2 3 4 5 6
** N=6 EP=5 FDC=10
X0 3 4 5 3 2 6 NE3I_6 w=1e-05 l=2.5e-06 as=2.7e-12 ad=4.8e-12 ps=1.054e-05 pd=2.096e-05 $X=0 $Y=0 $dt=7
X1 5 4 3 3 2 6 NE3I_6 w=1e-05 l=2.5e-06 as=2.7e-12 ad=2.7e-12 ps=1.054e-05 pd=1.054e-05 $X=3040 $Y=0 $dt=7
X2 3 4 5 3 2 6 NE3I_6 w=1e-05 l=2.5e-06 as=2.7e-12 ad=2.7e-12 ps=1.054e-05 pd=1.054e-05 $X=6080 $Y=0 $dt=7
X3 5 4 3 3 2 6 NE3I_6 w=1e-05 l=2.5e-06 as=2.7e-12 ad=2.7e-12 ps=1.054e-05 pd=1.054e-05 $X=9120 $Y=0 $dt=7
X4 3 4 5 3 2 6 NE3I_6 w=1e-05 l=2.5e-06 as=2.7e-12 ad=2.7e-12 ps=1.054e-05 pd=1.054e-05 $X=12160 $Y=0 $dt=7
X5 5 4 3 3 2 6 NE3I_6 w=1e-05 l=2.5e-06 as=2.7e-12 ad=2.7e-12 ps=1.054e-05 pd=1.054e-05 $X=15200 $Y=0 $dt=7
X6 3 4 5 3 2 6 NE3I_6 w=1e-05 l=2.5e-06 as=2.7e-12 ad=2.7e-12 ps=1.054e-05 pd=1.054e-05 $X=18240 $Y=0 $dt=7
X7 5 4 3 3 2 6 NE3I_6 w=1e-05 l=2.5e-06 as=4.8e-12 ad=2.7e-12 ps=2.096e-05 pd=1.054e-05 $X=21280 $Y=0 $dt=7
D8 6 2 p_ddnw AREA=5.2432e-10 PJ=0.00011224 perimeter=0.00011224 $X=-6110 $Y=-4940 $dt=15
D9 3 2 p_dipdnwmv AREA=1.51486e-10 PJ=8.144e-05 perimeter=8.144e-05 $X=-2260 $Y=-1090 $dt=19
.ends ne3i_6_CDNS_7290843938372

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938373                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938373 1 2 3
*.DEVICECLIMB
** N=4 EP=3 FDC=1
R0 2 1 L=0.0002878 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=38
.ends rpp1k1_3_CDNS_7290843938373

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: constant_gm                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt constant_gm 1 2 3 4 5 6
** N=17 EP=6 FDC=56
X65 1 2 15 6 ne3i_6_CDNS_7290843938366 $T=18020 14875 0 0 $X=7250 $Y=5275
X66 16 10 6 pe3_CDNS_7290843938367 $T=10155 41775 0 0 $X=8645 $Y=39735
X67 9 16 6 pe3_CDNS_7290843938367 $T=20155 47905 1 180 $X=8645 $Y=45865
X68 15 10 10 6 ne3_CDNS_7290843938368 $T=25460 39505 0 0 $X=24660 $Y=39105
X69 7 10 9 6 ne3_CDNS_7290843938368 $T=34790 39505 0 0 $X=33990 $Y=39105
X70 11 9 10 2 6 pe3_CDNS_7290843938369 $T=11660 58745 0 0 $X=10150 $Y=57715
X71 8 9 9 2 6 pe3_CDNS_7290843938369 $T=21810 58745 0 0 $X=20300 $Y=57715
X72 12 9 3 2 6 pe3_CDNS_7290843938369 $T=32565 58745 0 0 $X=31055 $Y=57715
X73 13 9 4 2 6 pe3_CDNS_7290843938369 $T=43380 58745 0 0 $X=41870 $Y=57715
X74 14 9 5 2 6 pe3_CDNS_7290843938370 $T=53845 58745 0 0 $X=52335 $Y=57715
X75 2 2 2 pe3_CDNS_7290843938371 $T=18765 87600 1 0 $X=17255 $Y=76570
X76 2 2 2 pe3_CDNS_7290843938371 $T=18765 106960 1 0 $X=17255 $Y=95930
X77 2 8 13 pe3_CDNS_7290843938371 $T=22505 87600 1 0 $X=20995 $Y=76570
X78 2 8 13 pe3_CDNS_7290843938371 $T=22505 106960 1 0 $X=20995 $Y=95930
X79 2 8 8 pe3_CDNS_7290843938371 $T=26245 87600 1 0 $X=24735 $Y=76570
X80 2 8 11 pe3_CDNS_7290843938371 $T=26245 106960 1 0 $X=24735 $Y=95930
X81 2 8 11 pe3_CDNS_7290843938371 $T=29985 87600 1 0 $X=28475 $Y=76570
X82 2 8 8 pe3_CDNS_7290843938371 $T=29985 106960 1 0 $X=28475 $Y=95930
X83 2 8 12 pe3_CDNS_7290843938371 $T=33725 87600 1 0 $X=32215 $Y=76570
X84 2 8 12 pe3_CDNS_7290843938371 $T=33725 106960 1 0 $X=32215 $Y=95930
X85 2 2 2 pe3_CDNS_7290843938371 $T=37465 87600 1 0 $X=35955 $Y=76570
X86 2 8 14 pe3_CDNS_7290843938371 $T=37465 106960 1 0 $X=35955 $Y=95930
X87 2 2 2 pe3_CDNS_7290843938371 $T=41205 87600 1 0 $X=39695 $Y=76570
X88 2 2 2 pe3_CDNS_7290843938371 $T=41205 106960 1 0 $X=39695 $Y=95930
X89 2 17 15 7 6 ne3i_6_CDNS_7290843938372 $T=48275 14875 0 0 $X=37505 $Y=5275
X90 1 17 2 rpp1k1_3_CDNS_7290843938373 $T=62765 46455 1 90 $X=62545 $Y=41295
D0 6 2 p_dnw AREA=4.77568e-10 PJ=0.00014131 perimeter=0.00014131 $X=7700 $Y=53605 $dt=12
D1 6 2 p_dnw AREA=1.16854e-09 PJ=0.00017172 perimeter=0.00017172 $X=12555 $Y=74150 $dt=12
D2 6 2 p_dnw AREA=1.48411e-09 PJ=0.00019385 perimeter=0.00019385 $X=61625 $Y=40375 $dt=12
D3 6 2 p_dnw3 AREA=3.37198e-10 PJ=0 perimeter=0 $X=17255 $Y=76570 $dt=36
D4 6 2 p_dnw3 AREA=3.37198e-10 PJ=0 perimeter=0 $X=17255 $Y=95930 $dt=36
.ends constant_gm

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: bias                                            *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt bias 1 2 3 4 5 6 7 8
** N=10 EP=8 FDC=460
X2 1 3 9 5 7 6 4 8 ref_bias $T=469540 4625 0 0 $X=471000 $Y=6590
X3 1 3 10 4 8 bandgap_su $T=97685 3355 0 0 $X=99220 $Y=6370
X4 1 3 8 mosvc3_CDNS_7290843938365 $T=25775 183420 1 0 $X=24975 $Y=157800
X5 1 3 8 mosvc3_CDNS_7290843938365 $T=25775 185680 0 0 $X=24975 $Y=185250
X6 1 3 8 mosvc3_CDNS_7290843938365 $T=58775 183420 1 0 $X=57975 $Y=157800
X7 1 3 8 mosvc3_CDNS_7290843938365 $T=58775 185680 0 0 $X=57975 $Y=185250
X8 1 3 8 mosvc3_CDNS_7290843938365 $T=91775 183420 1 0 $X=90975 $Y=157800
X9 1 3 8 mosvc3_CDNS_7290843938365 $T=91775 185680 0 0 $X=90975 $Y=185250
X10 1 3 8 mosvc3_CDNS_7290843938365 $T=124775 183420 1 0 $X=123975 $Y=157800
X11 1 3 8 mosvc3_CDNS_7290843938365 $T=124775 185680 0 0 $X=123975 $Y=185250
X12 1 3 8 mosvc3_CDNS_7290843938365 $T=157775 183420 1 0 $X=156975 $Y=157800
X13 1 3 8 mosvc3_CDNS_7290843938365 $T=157775 185680 0 0 $X=156975 $Y=185250
X14 1 3 8 mosvc3_CDNS_7290843938365 $T=190775 183420 1 0 $X=189975 $Y=157800
X15 1 3 8 mosvc3_CDNS_7290843938365 $T=190775 185680 0 0 $X=189975 $Y=185250
X16 1 3 8 mosvc3_CDNS_7290843938365 $T=223775 183420 1 0 $X=222975 $Y=157800
X17 1 3 8 mosvc3_CDNS_7290843938365 $T=223775 185680 0 0 $X=222975 $Y=185250
X18 1 3 8 mosvc3_CDNS_7290843938365 $T=256775 183420 1 0 $X=255975 $Y=157800
X19 1 3 8 mosvc3_CDNS_7290843938365 $T=256775 185680 0 0 $X=255975 $Y=185250
X20 1 3 8 mosvc3_CDNS_7290843938365 $T=289775 183420 1 0 $X=288975 $Y=157800
X21 1 3 8 mosvc3_CDNS_7290843938365 $T=289775 185680 0 0 $X=288975 $Y=185250
X22 1 3 8 mosvc3_CDNS_7290843938365 $T=322775 183420 1 0 $X=321975 $Y=157800
X23 1 3 8 mosvc3_CDNS_7290843938365 $T=322775 185680 0 0 $X=321975 $Y=185250
X24 1 3 8 mosvc3_CDNS_7290843938365 $T=355775 183420 1 0 $X=354975 $Y=157800
X25 1 3 8 mosvc3_CDNS_7290843938365 $T=355775 185680 0 0 $X=354975 $Y=185250
X26 1 3 8 mosvc3_CDNS_7290843938365 $T=388775 183420 1 0 $X=387975 $Y=157800
X27 1 3 8 mosvc3_CDNS_7290843938365 $T=388775 185680 0 0 $X=387975 $Y=185250
X28 1 3 8 mosvc3_CDNS_7290843938365 $T=421775 183420 1 0 $X=420975 $Y=157800
X29 1 3 8 mosvc3_CDNS_7290843938365 $T=421775 185680 0 0 $X=420975 $Y=185250
X30 1 3 9 10 2 8 constant_gm $T=6360 5750 0 0 $X=7225 $Y=6590
.ends bias

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EN2JI3VX0                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EN2JI3VX0 vdd3i! gnd3i! A B Q
*.DEVICECLIMB
** N=10 EP=5 FDC=10
M0 8 A 7 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=620 $Y=980 $dt=5
M1 gnd3i! B 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=1220 $Y=980 $dt=5
M2 9 A gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=1.134e-13 PD=9.6e-07 PS=9.6e-07 $X=2110 $Y=980 $dt=5
M3 gnd3i! B 9 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=3.698e-13 AS=1.134e-13 PD=3.22e-06 PS=9.6e-07 $X=3000 $Y=980 $dt=5
M4 Q 7 9 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=2.058e-13 PD=1.8e-06 PS=1.82e-06 $X=4440 $Y=1020 $dt=5
M5 7 A vdd3i! vdd3i! pe3i L=3e-07 W=9e-07 AD=3.195e-13 AS=8.517e-13 PD=1.61e-06 PS=4.61e-06 $X=685 $Y=2410 $dt=6
M6 vdd3i! B 7 vdd3i! pe3i L=3e-07 W=9e-07 AD=4.30855e-13 AS=3.195e-13 PD=1.83273e-06 PS=1.61e-06 $X=1695 $Y=2410 $dt=6
M7 10 A vdd3i! vdd3i! pe3i L=3e-07 W=1.3e-06 AD=1.95e-13 AS=6.22345e-13 PD=1.6e-06 PS=2.64727e-06 $X=2825 $Y=2520 $dt=6
M8 Q B 10 vdd3i! pe3i L=3e-07 W=1.3e-06 AD=6.21324e-13 AS=1.95e-13 PD=2.52941e-06 PS=1.6e-06 $X=3425 $Y=2520 $dt=6
M9 vdd3i! 7 Q vdd3i! pe3i L=3e-07 W=9.1e-07 AD=8.0675e-13 AS=4.34926e-13 PD=4.39e-06 PS=1.77059e-06 $X=4575 $Y=2520 $dt=6
.ends EN2JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO3JI3VX1                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO3JI3VX1 vdd3i! gnd3i! C Q B A
*.DEVICECLIMB
** N=9 EP=6 FDC=6
M0 Q C gnd3i! gnd3i! ne3i L=3.4986e-07 W=8.92071e-07 AD=2.37813e-13 AS=4.30337e-13 PD=1.42707e-06 PS=2.76707e-06 $X=620 $Y=660 $dt=5
M1 gnd3i! B Q gnd3i! ne3i L=3.4986e-07 W=8.92071e-07 AD=2.40287e-13 AS=2.37813e-13 PD=1.44207e-06 PS=1.42707e-06 $X=1500 $Y=660 $dt=5
M2 Q A gnd3i! gnd3i! ne3i L=3.4986e-07 W=8.92071e-07 AD=4.29162e-13 AS=2.40287e-13 PD=2.74707e-06 PS=1.44207e-06 $X=2390 $Y=660 $dt=5
M3 8 C vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.1855e-13 AS=1.3994e-12 PD=1.72e-06 PS=5.15e-06 $X=955 $Y=2410 $dt=6
M4 9 B 8 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.1855e-13 AS=2.1855e-13 PD=1.72e-06 PS=1.72e-06 $X=1565 $Y=2410 $dt=6
M5 Q A 9 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=2.1855e-13 PD=3.78e-06 PS=1.72e-06 $X=2175 $Y=2410 $dt=6
.ends NO3JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA2JI3VX2                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA2JI3VX2 vdd3i! gnd3i! B Q A
*.DEVICECLIMB
** N=8 EP=5 FDC=8
M0 7 B gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=7.09e-13 PD=1.14e-06 PS=3.68e-06 $X=740 $Y=660 $dt=5
M1 Q A 7 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=1.1125e-13 PD=1.43e-06 PS=1.14e-06 $X=1340 $Y=660 $dt=5
M2 8 A Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=2.403e-13 PD=1.14e-06 PS=1.43e-06 $X=2230 $Y=660 $dt=5
M3 gnd3i! B 8 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=7.09e-13 AS=1.1125e-13 PD=3.68e-06 PS=1.14e-06 $X=2830 $Y=660 $dt=5
M4 Q B vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=2.7e-13 AS=8.172e-13 PD=1.54e-06 PS=4.22e-06 $X=540 $Y=2410 $dt=6
M5 vdd3i! A Q vdd3i! pe3i L=3e-07 W=1e-06 AD=8.172e-13 AS=2.7e-13 PD=4.22e-06 PS=1.54e-06 $X=1380 $Y=2410 $dt=6
M6 Q A vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=2.7e-13 AS=8.172e-13 PD=1.54e-06 PS=4.22e-06 $X=2240 $Y=2410 $dt=6
M7 vdd3i! B Q vdd3i! pe3i L=3e-07 W=1e-06 AD=8.172e-13 AS=2.7e-13 PD=4.22e-06 PS=1.54e-06 $X=3080 $Y=2410 $dt=6
.ends NA2JI3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO22JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO22JI3VX1 vdd3i! gnd3i! B A Q C
*.DEVICECLIMB
** N=10 EP=6 FDC=8
M0 8 B gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=4.87734e-13 PD=9.6e-07 PS=2.24324e-06 $X=720 $Y=1130 $dt=5
M1 gnd3i! A 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=4.87734e-13 AS=1.134e-13 PD=2.24324e-06 PS=9.6e-07 $X=1610 $Y=1130 $dt=5
M2 Q 8 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=1.03353e-12 PD=1.43e-06 PS=4.75353e-06 $X=2580 $Y=660 $dt=5
M3 gnd3i! C Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=6.098e-13 AS=2.403e-13 PD=3.52e-06 PS=1.43e-06 $X=3470 $Y=660 $dt=5
M4 9 B vdd3i! vdd3i! pe3i L=3e-07 W=8.5e-07 AD=1.0625e-13 AS=1.0178e-12 PD=1.1e-06 PS=4.78e-06 $X=770 $Y=2410 $dt=6
M5 8 A 9 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=4.505e-13 AS=1.0625e-13 PD=2.76e-06 PS=1.1e-06 $X=1320 $Y=2410 $dt=6
M6 10 8 Q vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=6.768e-13 PD=1.66e-06 PS=3.78e-06 $X=2920 $Y=2410 $dt=6
M7 vdd3i! C 10 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=9.682e-13 AS=1.7625e-13 PD=4.66e-06 PS=1.66e-06 $X=3470 $Y=2410 $dt=6
.ends NO22JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DFRRQJI3VX2                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DFRRQJI3VX2 vdd3i! gnd3i! RN D C Q
*.DEVICECLIMB
** N=23 EP=6 FDC=32
M0 gnd3i! 17 11 gnd3i! ne3i L=3.5e-07 W=6.6e-07 AD=1.94849e-13 AS=3.168e-13 PD=1.21781e-06 PS=2.28e-06 $X=620 $Y=660 $dt=5
M1 8 RN gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.28952e-13 AS=2.62751e-13 PD=2.36956e-06 PS=1.64219e-06 $X=1510 $Y=660 $dt=5
M2 13 11 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.55236e-13 PD=6.7e-07 PS=1.11822e-06 $X=2340 $Y=1390 $dt=5
M3 17 9 13 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=2940 $Y=1390 $dt=5
M4 14 19 17 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.134e-13 PD=6.7e-07 PS=9.6e-07 $X=3830 $Y=1390 $dt=5
M5 8 D 14 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.835e-13 AS=5.25e-14 PD=2.19e-06 PS=6.7e-07 $X=4430 $Y=1390 $dt=5
M6 gnd3i! C 19 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.659e-13 AS=2.016e-13 PD=1.21e-06 PS=1.8e-06 $X=6060 $Y=1390 $dt=5
M7 9 19 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.95e-13 AS=1.659e-13 PD=2.23e-06 PS=1.21e-06 $X=7045 $Y=1390 $dt=5
M8 16 11 10 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=8695 $Y=1020 $dt=5
M9 18 9 16 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=9295 $Y=1020 $dt=5
M10 15 19 18 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.134e-13 PD=6.7e-07 PS=9.6e-07 $X=10185 $Y=1020 $dt=5
M11 10 12 15 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.55817e-13 AS=5.25e-14 PD=9.68244e-07 PS=6.7e-07 $X=10785 $Y=1020 $dt=5
M12 gnd3i! RN 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=5.94987e-13 AS=3.30183e-13 PD=3.35209e-06 PS=2.05176e-06 $X=11755 $Y=660 $dt=5
M13 12 18 gnd3i! gnd3i! ne3i L=3.5e-07 W=6.6e-07 AD=3.168e-13 AS=4.41226e-13 PD=2.28e-06 PS=2.48582e-06 $X=12750 $Y=890 $dt=5
M14 Q 18 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=5.94987e-13 PD=1.43e-06 PS=3.35209e-06 $X=14380 $Y=660 $dt=5
M15 gnd3i! 18 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=2.403e-13 PD=2.74e-06 PS=1.43e-06 $X=15270 $Y=660 $dt=5
M16 vdd3i! 17 11 vdd3i! pe3i L=3e-07 W=1e-06 AD=2.97674e-13 AS=4.8e-13 PD=1.7907e-06 PS=2.96e-06 $X=620 $Y=2670 $dt=6
M17 17 RN vdd3i! vdd3i! pe3i L=3e-07 W=7.2e-07 AD=3.136e-13 AS=2.14326e-13 PD=2.4e-06 PS=1.2893e-06 $X=1460 $Y=2670 $dt=6
M18 20 11 vdd3i! vdd3i! pe3i L=3e-07 W=4.2e-07 AD=5.25e-14 AS=5.1875e-13 PD=6.7e-07 PS=2.99e-06 $X=3080 $Y=3400 $dt=6
M19 17 19 20 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=1.21617e-13 AS=5.25e-14 PD=9.13043e-07 PS=6.7e-07 $X=3630 $Y=3400 $dt=6
M20 22 9 17 vdd3i! pe3i L=3e-07 W=9.6e-07 AD=1.2e-13 AS=2.77983e-13 PD=1.21e-06 PS=2.08696e-06 $X=4470 $Y=2860 $dt=6
M21 vdd3i! D 22 vdd3i! pe3i L=3e-07 W=9.6e-07 AD=5.00229e-13 AS=1.2e-13 PD=2.34286e-06 PS=1.21e-06 $X=5020 $Y=2860 $dt=6
M22 19 C vdd3i! vdd3i! pe3i L=3e-07 W=7.2e-07 AD=4.56625e-13 AS=3.75171e-13 PD=2.86e-06 PS=1.75714e-06 $X=6060 $Y=2860 $dt=6
M23 vdd3i! 19 9 vdd3i! pe3i L=3e-07 W=7.2e-07 AD=3.92547e-13 AS=3.528e-13 PD=1.8586e-06 PS=2.42e-06 $X=7720 $Y=2670 $dt=6
M24 23 11 vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=1.25e-13 AS=5.45203e-13 PD=1.25e-06 PS=2.5814e-06 $X=8740 $Y=2820 $dt=6
M25 18 19 23 vdd3i! pe3i L=3e-07 W=1e-06 AD=2.96338e-13 AS=1.25e-13 PD=2.19718e-06 PS=1.25e-06 $X=9290 $Y=2820 $dt=6
M26 21 9 18 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=5.25e-14 AS=1.24462e-13 PD=6.7e-07 PS=9.22817e-07 $X=10150 $Y=3235 $dt=6
M27 vdd3i! 12 21 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=3.93439e-13 AS=5.25e-14 PD=1.64096e-06 PS=6.7e-07 $X=10700 $Y=3235 $dt=6
M28 vdd3i! RN 18 vdd3i! pe3i L=3e-07 W=7.2e-07 AD=6.74468e-13 AS=2.976e-13 PD=2.81307e-06 PS=2.4e-06 $X=11900 $Y=2410 $dt=6
M29 12 18 vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=4.8e-13 AS=9.36761e-13 PD=2.96e-06 PS=3.90704e-06 $X=12740 $Y=2410 $dt=6
M30 Q 18 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.807e-13 AS=1.32083e-12 PD=1.95e-06 PS=5.50893e-06 $X=14440 $Y=2410 $dt=6
M31 vdd3i! 18 Q vdd3i! pe3i L=3e-07 W=1.41e-06 AD=8.802e-13 AS=3.807e-13 PD=4.56e-06 PS=1.95e-06 $X=15280 $Y=2410 $dt=6
.ends DFRRQJI3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BUJI3VX8                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BUJI3VX8 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=6 EP=4 FDC=19
M0 6 A gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=6.098e-13 PD=1.43e-06 PS=3.52e-06 $X=660 $Y=660 $dt=5
M1 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.804e-13 AS=2.403e-13 PD=1.91e-06 PS=1.43e-06 $X=1550 $Y=660 $dt=5
M2 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=3.804e-13 PD=1.43e-06 PS=1.91e-06 $X=2570 $Y=660 $dt=5
M3 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.494e-13 AS=2.403e-13 PD=1.86e-06 PS=1.43e-06 $X=3460 $Y=660 $dt=5
M4 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=3.494e-13 PD=1.43e-06 PS=1.86e-06 $X=4430 $Y=660 $dt=5
M5 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.494e-13 AS=2.403e-13 PD=1.86e-06 PS=1.43e-06 $X=5320 $Y=660 $dt=5
M6 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=3.494e-13 PD=1.43e-06 PS=1.86e-06 $X=6290 $Y=660 $dt=5
M7 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=8.702e-13 AS=2.403e-13 PD=3.94e-06 PS=1.43e-06 $X=7180 $Y=660 $dt=5
M8 vdd3i! A 6 vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=5.51013e-13 PD=1.86506e-06 PS=3.69506e-06 $X=620 $Y=2410 $dt=6
M9 6 A vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.61963e-13 AS=2.83187e-13 PD=1.87506e-06 PS=1.86506e-06 $X=1170 $Y=2410 $dt=6
M10 vdd3i! A 6 vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.61963e-13 PD=1.86506e-06 PS=1.87506e-06 $X=2020 $Y=2410 $dt=6
M11 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.61963e-13 AS=2.83187e-13 PD=1.87506e-06 PS=1.86506e-06 $X=2570 $Y=2410 $dt=6
M12 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.61963e-13 PD=1.86506e-06 PS=1.87506e-06 $X=3420 $Y=2410 $dt=6
M13 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.61963e-13 AS=2.83187e-13 PD=1.87506e-06 PS=1.86506e-06 $X=3970 $Y=2410 $dt=6
M14 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.61963e-13 PD=1.86506e-06 PS=1.87506e-06 $X=4820 $Y=2410 $dt=6
M15 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.61963e-13 AS=2.83187e-13 PD=1.87506e-06 PS=1.86506e-06 $X=5370 $Y=2410 $dt=6
M16 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.61963e-13 PD=1.86506e-06 PS=1.87506e-06 $X=6220 $Y=2410 $dt=6
M17 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.61963e-13 AS=2.83187e-13 PD=1.87506e-06 PS=1.86506e-06 $X=6770 $Y=2410 $dt=6
M18 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=5.79287e-13 AS=2.61963e-13 PD=3.69506e-06 PS=1.87506e-06 $X=7620 $Y=2410 $dt=6
.ends BUJI3VX8

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DFRRQJI3VX4                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DFRRQJI3VX4 vdd3i! gnd3i! RN D C Q
*.DEVICECLIMB
** N=23 EP=6 FDC=36
M0 gnd3i! 17 11 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=4.272e-13 PD=1.43e-06 PS=2.74e-06 $X=620 $Y=660 $dt=5
M1 8 RN gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.28952e-13 AS=2.403e-13 PD=2.36956e-06 PS=1.43e-06 $X=1510 $Y=660 $dt=5
M2 13 11 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.55236e-13 PD=6.7e-07 PS=1.11822e-06 $X=2340 $Y=1390 $dt=5
M3 17 9 13 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=2940 $Y=1390 $dt=5
M4 14 19 17 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.134e-13 PD=6.7e-07 PS=9.6e-07 $X=3830 $Y=1390 $dt=5
M5 8 D 14 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.835e-13 AS=5.25e-14 PD=2.19e-06 PS=6.7e-07 $X=4430 $Y=1390 $dt=5
M6 gnd3i! C 19 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.659e-13 AS=2.016e-13 PD=1.21e-06 PS=1.8e-06 $X=6060 $Y=1390 $dt=5
M7 9 19 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.95e-13 AS=1.659e-13 PD=2.23e-06 PS=1.21e-06 $X=7045 $Y=1390 $dt=5
M8 15 11 10 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=8695 $Y=1020 $dt=5
M9 18 9 15 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=9295 $Y=1020 $dt=5
M10 16 19 18 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.134e-13 PD=6.7e-07 PS=9.6e-07 $X=10185 $Y=1020 $dt=5
M11 10 12 16 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.55817e-13 AS=5.25e-14 PD=9.68244e-07 PS=6.7e-07 $X=10785 $Y=1020 $dt=5
M12 gnd3i! RN 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.60325e-13 AS=3.30183e-13 PD=1.475e-06 PS=2.05176e-06 $X=11755 $Y=660 $dt=5
M13 12 18 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=2.60325e-13 PD=2.74e-06 PS=1.475e-06 $X=12690 $Y=660 $dt=5
M14 Q 18 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=4.272e-13 PD=1.43e-06 PS=2.74e-06 $X=14280 $Y=660 $dt=5
M15 gnd3i! 18 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=15170 $Y=660 $dt=5
M16 Q 18 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=16060 $Y=660 $dt=5
M17 gnd3i! 18 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=2.403e-13 PD=2.74e-06 PS=1.43e-06 $X=16950 $Y=660 $dt=5
M18 vdd3i! 17 11 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.54046e-13 AS=6.768e-13 PD=2.58169e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=6
M19 17 RN vdd3i! vdd3i! pe3i L=3e-07 W=7.2e-07 AD=3.136e-13 AS=2.31854e-13 PD=2.4e-06 PS=1.31831e-06 $X=1460 $Y=2670 $dt=6
M20 20 11 vdd3i! vdd3i! pe3i L=3e-07 W=4.2e-07 AD=5.25e-14 AS=5.1875e-13 PD=6.7e-07 PS=2.99e-06 $X=3080 $Y=3400 $dt=6
M21 17 19 20 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=1.21617e-13 AS=5.25e-14 PD=9.13043e-07 PS=6.7e-07 $X=3630 $Y=3400 $dt=6
M22 22 9 17 vdd3i! pe3i L=3e-07 W=9.6e-07 AD=1.2e-13 AS=2.77983e-13 PD=1.21e-06 PS=2.08696e-06 $X=4470 $Y=2860 $dt=6
M23 vdd3i! D 22 vdd3i! pe3i L=3e-07 W=9.6e-07 AD=5.00229e-13 AS=1.2e-13 PD=2.34286e-06 PS=1.21e-06 $X=5020 $Y=2860 $dt=6
M24 19 C vdd3i! vdd3i! pe3i L=3e-07 W=7.2e-07 AD=4.94875e-13 AS=3.75171e-13 PD=3.04e-06 PS=1.75714e-06 $X=6060 $Y=2860 $dt=6
M25 vdd3i! 19 9 vdd3i! pe3i L=3e-07 W=7.2e-07 AD=3.92547e-13 AS=3.528e-13 PD=1.8586e-06 PS=2.42e-06 $X=7720 $Y=2670 $dt=6
M26 23 11 vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=1.25e-13 AS=5.45203e-13 PD=1.25e-06 PS=2.5814e-06 $X=8740 $Y=2820 $dt=6
M27 18 19 23 vdd3i! pe3i L=3e-07 W=1e-06 AD=2.96338e-13 AS=1.25e-13 PD=2.19718e-06 PS=1.25e-06 $X=9290 $Y=2820 $dt=6
M28 21 9 18 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=5.25e-14 AS=1.24462e-13 PD=6.7e-07 PS=9.22817e-07 $X=10150 $Y=3235 $dt=6
M29 vdd3i! 12 21 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=2.90656e-13 AS=5.25e-14 PD=1.25671e-06 PS=6.7e-07 $X=10700 $Y=3235 $dt=6
M30 vdd3i! RN 18 vdd3i! pe3i L=3e-07 W=7.2e-07 AD=4.98268e-13 AS=2.976e-13 PD=2.15435e-06 PS=2.4e-06 $X=11900 $Y=2410 $dt=6
M31 12 18 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=9.75775e-13 PD=3.78e-06 PS=4.21894e-06 $X=12740 $Y=2410 $dt=6
M32 Q 18 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.807e-13 AS=1.1618e-12 PD=1.95e-06 PS=4.88e-06 $X=14480 $Y=2410 $dt=6
M33 vdd3i! 18 Q vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.807e-13 AS=3.807e-13 PD=1.95e-06 PS=1.95e-06 $X=15320 $Y=2410 $dt=6
M34 Q 18 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.807e-13 AS=3.807e-13 PD=1.95e-06 PS=1.95e-06 $X=16160 $Y=2410 $dt=6
M35 vdd3i! 18 Q vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=3.807e-13 PD=3.78e-06 PS=1.95e-06 $X=17000 $Y=2410 $dt=6
.ends DFRRQJI3VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BUJI3VX1                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BUJI3VX1 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=6 EP=4 FDC=4
M0 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.44533e-13 AS=2.016e-13 PD=1.44667e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=5
M1 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=6.6e-07 AD=2.88e-13 AS=3.84267e-13 PD=2.28e-06 PS=2.27333e-06 $X=1590 $Y=890 $dt=5
M2 vdd3i! A 6 vdd3i! pe3i L=3e-07 W=9e-07 AD=4.7931e-13 AS=4.32e-13 PD=1.95649e-06 PS=2.76e-06 $X=620 $Y=2410 $dt=6
M3 Q 6 vdd3i! vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=5.712e-13 AS=7.7739e-13 PD=3.70971e-06 PS=3.17322e-06 $X=1640 $Y=2410 $dt=6
.ends BUJI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO3I2JI3VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO3I2JI3VX1 vdd3i! gnd3i! AN BN C Q
*.DEVICECLIMB
** N=10 EP=6 FDC=8
M0 9 AN 8 gnd3i! ne3i L=3.5e-07 W=4.8e-07 AD=6e-14 AS=2.304e-13 PD=7.3e-07 PS=1.92e-06 $X=620 $Y=1070 $dt=5
M1 gnd3i! BN 9 gnd3i! ne3i L=3.5e-07 W=4.8e-07 AD=1.98937e-13 AS=6e-14 PD=1.31617e-06 PS=7.3e-07 $X=1220 $Y=1070 $dt=5
M2 Q C gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=3.68863e-13 PD=1.43e-06 PS=2.4404e-06 $X=2060 $Y=660 $dt=5
M3 gnd3i! 8 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.329e-13 AS=2.403e-13 PD=2.77e-06 PS=1.43e-06 $X=2950 $Y=660 $dt=5
M4 8 AN vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=1.89e-13 AS=5.71409e-13 PD=1.24e-06 PS=2.5758e-06 $X=560 $Y=2590 $dt=6
M5 vdd3i! BN 8 vdd3i! pe3i L=3e-07 W=7e-07 AD=5.71409e-13 AS=1.89e-13 PD=2.5758e-06 PS=1.24e-06 $X=1400 $Y=2590 $dt=6
M6 10 C vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=1.15098e-12 PD=1.66e-06 PS=5.1884e-06 $X=2330 $Y=2410 $dt=6
M7 Q 8 10 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=8.46e-13 AS=1.7625e-13 PD=4.02e-06 PS=1.66e-06 $X=2880 $Y=2410 $dt=6
.ends NO3I2JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: FAJI3VX1                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt FAJI3VX1 vdd3i! gnd3i! S CI B A CO
*.DEVICECLIMB
** N=20 EP=7 FDC=28
M0 gnd3i! 9 S gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.361e-13 AS=4.272e-13 PD=2.76e-06 PS=2.74e-06 $X=620 $Y=660 $dt=5
M1 11 CI 9 gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=7.375e-14 AS=2.832e-13 PD=8.4e-07 PS=2.14e-06 $X=2220 $Y=960 $dt=5
M2 10 B 11 gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=7.375e-14 AS=7.375e-14 PD=8.4e-07 PS=8.4e-07 $X=2820 $Y=960 $dt=5
M3 gnd3i! A 10 gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=2.34033e-13 AS=7.375e-14 PD=1.52158e-06 PS=8.4e-07 $X=3420 $Y=960 $dt=5
M4 13 CI gnd3i! gnd3i! ne3i L=3.5e-07 W=5.5e-07 AD=1.485e-13 AS=2.18167e-13 PD=1.09e-06 PS=1.41842e-06 $X=4350 $Y=660 $dt=5
M5 gnd3i! A 13 gnd3i! ne3i L=3.5e-07 W=5.5e-07 AD=2.5017e-13 AS=1.485e-13 PD=1.58058e-06 PS=1.09e-06 $X=5240 $Y=660 $dt=5
M6 13 B gnd3i! gnd3i! ne3i L=3.5e-07 W=4.8e-07 AD=1.296e-13 AS=2.1833e-13 PD=1.02e-06 PS=1.37942e-06 $X=6220 $Y=960 $dt=5
M7 9 14 13 gnd3i! ne3i L=3.5e-07 W=4.8e-07 AD=2.304e-13 AS=1.296e-13 PD=1.92e-06 PS=1.02e-06 $X=7110 $Y=960 $dt=5
M8 gnd3i! 14 CO gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=3.345e-13 AS=2.832e-13 PD=1.73e-06 PS=2.14e-06 $X=8700 $Y=960 $dt=5
M9 12 A gnd3i! gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=7.375e-14 AS=3.345e-13 PD=8.4e-07 PS=1.73e-06 $X=9830 $Y=960 $dt=5
M10 14 B 12 gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=1.593e-13 AS=7.375e-14 PD=1.13e-06 PS=8.4e-07 $X=10430 $Y=960 $dt=5
M11 15 CI 14 gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=1.593e-13 AS=1.593e-13 PD=1.13e-06 PS=1.13e-06 $X=11320 $Y=960 $dt=5
M12 gnd3i! B 15 gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=4.382e-13 AS=1.593e-13 PD=1.95e-06 PS=1.13e-06 $X=12210 $Y=960 $dt=5
M13 15 A gnd3i! gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=3.068e-13 AS=4.382e-13 PD=2.22e-06 PS=1.95e-06 $X=13550 $Y=960 $dt=5
M14 vdd3i! 9 S vdd3i! pe3i L=3e-07 W=1.41e-06 AD=7.6395e-13 AS=7.1205e-13 PD=4.52213e-06 PS=3.83e-06 $X=645 $Y=2410 $dt=6
M15 vdd3i! CI 17 vdd3i! pe3i L=3e-07 W=1.03e-06 AD=4.8155e-13 AS=4.79437e-13 PD=2.35e-06 PS=3.03778e-06 $X=2125 $Y=2490 $dt=6
M16 17 B vdd3i! vdd3i! pe3i L=3e-07 W=1.03e-06 AD=3.0385e-13 AS=4.8155e-13 PD=1.62e-06 PS=2.35e-06 $X=3095 $Y=2490 $dt=6
M17 vdd3i! A 17 vdd3i! pe3i L=3e-07 W=1.03e-06 AD=4.1015e-13 AS=3.0385e-13 PD=2.01e-06 PS=1.62e-06 $X=3985 $Y=2490 $dt=6
M18 18 A vdd3i! vdd3i! pe3i L=3e-07 W=1.03e-06 AD=1.545e-13 AS=4.1015e-13 PD=1.33e-06 PS=2.01e-06 $X=4955 $Y=2490 $dt=6
M19 19 B 18 vdd3i! pe3i L=3e-07 W=1.03e-06 AD=1.545e-13 AS=1.545e-13 PD=1.33e-06 PS=1.33e-06 $X=5555 $Y=2490 $dt=6
M20 9 CI 19 vdd3i! pe3i L=3e-07 W=1.03e-06 AD=3.0385e-13 AS=1.545e-13 PD=1.62e-06 PS=1.33e-06 $X=6155 $Y=2490 $dt=6
M21 17 14 9 vdd3i! pe3i L=3e-07 W=1.03e-06 AD=6.9155e-13 AS=3.0385e-13 PD=3.77e-06 PS=1.62e-06 $X=7045 $Y=2490 $dt=6
M22 vdd3i! 14 CO vdd3i! pe3i L=3e-07 W=1.11e-06 AD=4.54624e-13 AS=5.6055e-13 PD=2.27286e-06 PS=3.23e-06 $X=8675 $Y=2410 $dt=6
M23 16 A vdd3i! vdd3i! pe3i L=3e-07 W=9.9e-07 AD=2.9205e-13 AS=4.05476e-13 PD=1.58e-06 PS=2.02714e-06 $X=9645 $Y=2530 $dt=6
M24 vdd3i! B 16 vdd3i! pe3i L=3e-07 W=9.9e-07 AD=5.763e-13 AS=2.9205e-13 PD=3.59e-06 PS=1.58e-06 $X=10535 $Y=2530 $dt=6
M25 14 CI 16 vdd3i! pe3i L=3e-07 W=1e-06 AD=2.95e-13 AS=4.65e-13 PD=1.59e-06 PS=3.01e-06 $X=12085 $Y=2520 $dt=6
M26 20 B 14 vdd3i! pe3i L=3e-07 W=1e-06 AD=1.5e-13 AS=2.95e-13 PD=1.3e-06 PS=1.59e-06 $X=12975 $Y=2520 $dt=6
M27 vdd3i! A 20 vdd3i! pe3i L=3e-07 W=1e-06 AD=8.18e-13 AS=1.5e-13 PD=4.39e-06 PS=1.3e-06 $X=13575 $Y=2520 $dt=6
.ends FAJI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OR2JI3VX0                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OR2JI3VX0 vdd3i! gnd3i! A B Q
*.DEVICECLIMB
** N=8 EP=5 FDC=6
M0 7 A gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.75467e-13 PD=9.6e-07 PS=2.95333e-06 $X=530 $Y=1130 $dt=5
M1 gnd3i! B 7 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.75467e-13 AS=1.134e-13 PD=2.95333e-06 PS=9.6e-07 $X=1420 $Y=1130 $dt=5
M2 Q 7 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=5.75467e-13 PD=1.8e-06 PS=2.95333e-06 $X=2390 $Y=1130 $dt=5
M3 8 A 7 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=1.0625e-13 AS=4.08e-13 PD=1.1e-06 PS=2.66e-06 $X=620 $Y=2410 $dt=6
M4 vdd3i! B 8 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=8.28174e-13 AS=1.0625e-13 PD=2.99419e-06 PS=1.1e-06 $X=1170 $Y=2410 $dt=6
M5 Q 7 vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=3.36e-13 AS=6.82026e-13 PD=2.36e-06 PS=2.46581e-06 $X=2440 $Y=2410 $dt=6
.ends OR2JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA3I1JI3VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA3I1JI3VX1 vdd3i! gnd3i! AN Q B C
*.DEVICECLIMB
** N=10 EP=6 FDC=8
M0 gnd3i! AN 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.40779e-13 AS=2.016e-13 PD=1.24397e-06 PS=1.8e-06 $X=620 $Y=660 $dt=5
M1 9 8 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.26825e-13 AS=5.10221e-13 PD=1.175e-06 PS=2.63603e-06 $X=1670 $Y=660 $dt=5
M2 10 B 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.31275e-13 AS=1.26825e-13 PD=1.185e-06 PS=1.175e-06 $X=2305 $Y=660 $dt=5
M3 Q C 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=1.31275e-13 PD=2.74e-06 PS=1.185e-06 $X=2950 $Y=660 $dt=5
M4 vdd3i! AN 8 vdd3i! pe3i L=3e-07 W=7e-07 AD=4.82246e-13 AS=3.36e-13 PD=2.26063e-06 PS=2.36e-06 $X=620 $Y=2410 $dt=6
M5 vdd3i! 8 Q vdd3i! pe3i L=3.00059e-07 W=1.00314e-06 AD=6.91085e-13 AS=2.195e-13 PD=3.2396e-06 PS=1.46314e-06 $X=1430 $Y=2410 $dt=6
M6 Q B vdd3i! vdd3i! pe3i L=3.00059e-07 W=1.00314e-06 AD=2.195e-13 AS=6.91085e-13 PD=1.46314e-06 PS=3.2396e-06 $X=2270 $Y=2410 $dt=6
M7 Q C vdd3i! vdd3i! pe3i L=3.00059e-07 W=1.00314e-06 AD=4.232e-13 AS=6.91085e-13 PD=2.85314e-06 PS=3.2396e-06 $X=3000 $Y=2410 $dt=6
.ends NA3I1JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DLY2JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DLY2JI3VX1 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=12 EP=4 FDC=12
M0 gnd3i! A 9 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=3.577e-13 AS=2.016e-13 PD=1.79e-06 PS=1.8e-06 $X=620 $Y=660 $dt=5
M1 6 9 gnd3i! gnd3i! ne3i L=8e-07 W=4.2e-07 AD=2.548e-13 AS=3.577e-13 PD=1.7e-06 PS=1.79e-06 $X=1990 $Y=660 $dt=5
M2 6 9 10 gnd3i! ne3i L=8e-07 W=4.2e-07 AD=2.548e-13 AS=2.016e-13 PD=1.7e-06 PS=1.8e-06 $X=1990 $Y=1360 $dt=5
M3 gnd3i! 10 7 gnd3i! ne3i L=1e-06 W=4.2e-07 AD=3.42444e-13 AS=2.1e-13 PD=1.66718e-06 PS=1.62e-06 $X=3950 $Y=660 $dt=5
M4 8 10 7 gnd3i! ne3i L=1e-06 W=4.2e-07 AD=2.10588e-13 AS=2.1e-13 PD=1.81778e-06 PS=1.62e-06 $X=3950 $Y=1360 $dt=5
M5 Q 8 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=7.25656e-13 PD=2.74e-06 PS=3.53282e-06 $X=6310 $Y=660 $dt=5
M6 vdd3i! A 9 vdd3i! pe3i L=3e-07 W=7e-07 AD=5.42937e-13 AS=3.535e-13 PD=2.69375e-06 PS=2.41e-06 $X=645 $Y=3120 $dt=6
M7 11 9 10 vdd3i! pe3i L=7.4e-07 W=4.2e-07 AD=2.8095e-13 AS=2.0035e-13 PD=1.785e-06 PS=1.77071e-06 $X=2050 $Y=2640 $dt=6
M8 11 9 vdd3i! vdd3i! pe3i L=7.4e-07 W=4.2e-07 AD=2.8095e-13 AS=3.25762e-13 PD=1.785e-06 PS=1.61625e-06 $X=2050 $Y=3400 $dt=6
M9 8 10 12 vdd3i! pe3i L=1e-06 W=4.2e-07 AD=2.856e-13 AS=2.479e-13 PD=2.2e-06 PS=1.715e-06 $X=4030 $Y=2660 $dt=6
M10 vdd3i! 10 12 vdd3i! pe3i L=1e-06 W=4.2e-07 AD=2.62018e-13 AS=2.479e-13 PD=1.40689e-06 PS=1.715e-06 $X=4030 $Y=3400 $dt=6
M11 Q 8 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=7.1205e-13 AS=8.79632e-13 PD=3.83e-06 PS=4.72311e-06 $X=6335 $Y=2410 $dt=6
.ends DLY2JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA3JI3VX0                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA3JI3VX0 vdd3i! gnd3i! C Q B A
*.DEVICECLIMB
** N=9 EP=6 FDC=6
M0 8 C gnd3i! gnd3i! ne3i L=3.5e-07 W=7e-07 AD=8.75e-14 AS=5.605e-13 PD=9.5e-07 PS=3.52e-06 $X=630 $Y=850 $dt=5
M1 9 B 8 gnd3i! ne3i L=3.5e-07 W=7e-07 AD=8.75e-14 AS=8.75e-14 PD=9.5e-07 PS=9.5e-07 $X=1230 $Y=850 $dt=5
M2 Q A 9 gnd3i! ne3i L=3.5e-07 W=7e-07 AD=3.36e-13 AS=8.75e-14 PD=2.36e-06 PS=9.5e-07 $X=1830 $Y=850 $dt=5
M3 Q C vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=1.89e-13 AS=5.76467e-13 PD=1.24e-06 PS=3.21333e-06 $X=470 $Y=2580 $dt=6
M4 vdd3i! B Q vdd3i! pe3i L=3e-07 W=7e-07 AD=5.76467e-13 AS=1.89e-13 PD=3.21333e-06 PS=1.24e-06 $X=1310 $Y=2580 $dt=6
M5 Q A vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=4.708e-13 AS=5.76467e-13 PD=3.92e-06 PS=3.21333e-06 $X=2040 $Y=2470 $dt=6
.ends NA3JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ON21JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ON21JI3VX1 vdd3i! gnd3i! B A Q C
*.DEVICECLIMB
** N=9 EP=6 FDC=6
M0 gnd3i! B 8 gnd3i! ne3i L=3.4958e-07 W=8.92071e-07 AD=2.40125e-13 AS=4.24712e-13 PD=1.43207e-06 PS=2.73707e-06 $X=615 $Y=660 $dt=5
M1 8 A gnd3i! gnd3i! ne3i L=3.4958e-07 W=8.92071e-07 AD=2.37987e-13 AS=2.40125e-13 PD=1.42707e-06 PS=1.43207e-06 $X=1505 $Y=660 $dt=5
M2 Q C 8 gnd3i! ne3i L=3.4958e-07 W=8.92071e-07 AD=4.24712e-13 AS=2.37987e-13 PD=2.73707e-06 PS=1.42707e-06 $X=2395 $Y=660 $dt=5
M3 9 B vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=9.418e-13 PD=1.66e-06 PS=4.63e-06 $X=695 $Y=2410 $dt=6
M4 Q A 9 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.75706e-13 AS=1.7625e-13 PD=2.44322e-06 PS=1.66e-06 $X=1245 $Y=2410 $dt=6
M5 vdd3i! C Q vdd3i! pe3i L=3e-07 W=9.85e-07 AD=1.1721e-12 AS=3.32319e-13 PD=4.94e-06 PS=1.70678e-06 $X=2210 $Y=2410 $dt=6
.ends ON21JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OA21JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OA21JI3VX1 vdd3i! gnd3i! C A B Q
*.DEVICECLIMB
** N=10 EP=6 FDC=8
M0 8 C 9 gnd3i! ne3i L=3.5e-07 W=5.4e-07 AD=3.313e-13 AS=2.97e-13 PD=1.95333e-06 PS=2.18e-06 $X=690 $Y=660 $dt=5
M1 8 A gnd3i! gnd3i! ne3i L=3.5e-07 W=5.4e-07 AD=3.313e-13 AS=2.592e-13 PD=1.95333e-06 PS=2.04e-06 $X=1620 $Y=1480 $dt=5
M2 gnd3i! B 8 gnd3i! ne3i L=3.5e-07 W=5.4e-07 AD=2.92808e-13 AS=3.313e-13 PD=1.47273e-06 PS=1.95333e-06 $X=2450 $Y=1010 $dt=5
M3 Q 9 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=4.82592e-13 PD=2.74e-06 PS=2.42727e-06 $X=3510 $Y=660 $dt=5
M4 9 C vdd3i! vdd3i! pe3i L=3e-07 W=8.5e-07 AD=2.295e-13 AS=1.03315e-12 PD=1.39e-06 PS=4.25e-06 $X=975 $Y=2880 $dt=6
M5 10 A 9 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=1.0625e-13 AS=2.295e-13 PD=1.1e-06 PS=1.39e-06 $X=1815 $Y=2880 $dt=6
M6 vdd3i! B 10 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=4.77448e-13 AS=1.0625e-13 PD=1.94425e-06 PS=1.1e-06 $X=2365 $Y=2880 $dt=6
M7 Q 9 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=7.92002e-13 PD=3.78e-06 PS=3.22516e-06 $X=3560 $Y=2410 $dt=6
.ends OA21JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BUJI3VX3                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BUJI3VX3 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=6 EP=4 FDC=7
M0 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=5.23e-13 AS=4.272e-13 PD=2.14e-06 PS=2.74e-06 $X=620 $Y=660 $dt=5
M1 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.5365e-13 AS=5.23e-13 PD=1.46e-06 PS=2.14e-06 $X=1870 $Y=660 $dt=5
M2 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=7.586e-13 AS=2.5365e-13 PD=3.76e-06 PS=1.46e-06 $X=2790 $Y=660 $dt=5
M3 vdd3i! A 6 vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=6.11825e-13 AS=5.712e-13 PD=2.51971e-06 PS=3.70971e-06 $X=620 $Y=2410 $dt=6
M4 Q 6 vdd3i! vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=2.751e-13 AS=6.11825e-13 PD=1.87971e-06 PS=2.51971e-06 $X=1510 $Y=2410 $dt=6
M5 vdd3i! 6 Q vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=3.3675e-13 AS=2.751e-13 PD=1.92971e-06 PS=1.87971e-06 $X=2350 $Y=2410 $dt=6
M6 Q 6 vdd3i! vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=5.712e-13 AS=3.3675e-13 PD=3.70971e-06 PS=1.92971e-06 $X=3000 $Y=2410 $dt=6
.ends BUJI3VX3

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AN211JI3VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AN211JI3VX1 vdd3i! gnd3i! B A Q C D
*.DEVICECLIMB
** N=11 EP=7 FDC=8
M0 9 B gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=6.47e-13 PD=1.14e-06 PS=3.58e-06 $X=690 $Y=660 $dt=5
M1 Q A 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.9785e-13 AS=1.1125e-13 PD=1.71704e-06 PS=1.14e-06 $X=1290 $Y=660 $dt=5
M2 gnd3i! C Q gnd3i! ne3i L=3.5e-07 W=6.65e-07 AD=5.036e-13 AS=2.2255e-13 PD=2.145e-06 PS=1.28296e-06 $X=2250 $Y=885 $dt=5
M3 Q D gnd3i! gnd3i! ne3i L=3.5e-07 W=6.65e-07 AD=3.22525e-13 AS=5.036e-13 PD=2.3e-06 PS=2.145e-06 $X=3505 $Y=885 $dt=5
M4 vdd3i! B 10 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.5825e-13 AS=6.768e-13 PD=2.06e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=6
M5 10 A vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.1595e-13 AS=4.5825e-13 PD=2e-06 PS=2.06e-06 $X=1570 $Y=2410 $dt=6
M6 11 C 10 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.115e-13 AS=4.1595e-13 PD=1.71e-06 PS=2e-06 $X=2460 $Y=2410 $dt=6
M7 Q D 11 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=2.115e-13 PD=3.78e-06 PS=1.71e-06 $X=3060 $Y=2410 $dt=6
.ends AN211JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BUJI3VX16                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BUJI3VX16 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=6 EP=4 FDC=39
M0 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=4.272e-13 PD=1.43e-06 PS=2.74e-06 $X=620 $Y=660 $dt=5
M1 6 A gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=1510 $Y=660 $dt=5
M2 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=2400 $Y=660 $dt=5
M3 6 A gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=3290 $Y=660 $dt=5
M4 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=4180 $Y=660 $dt=5
M5 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.4475e-13 AS=2.403e-13 PD=1.44e-06 PS=1.43e-06 $X=5070 $Y=660 $dt=5
M6 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.63267e-13 AS=2.4475e-13 PD=1.95905e-06 PS=1.44e-06 $X=5970 $Y=660 $dt=5
M7 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=3.26533e-13 PD=1.34e-06 PS=1.76095e-06 $X=6940 $Y=750 $dt=5
M8 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=7830 $Y=750 $dt=5
M9 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=3.404e-13 PD=1.34e-06 PS=1.86e-06 $X=8800 $Y=750 $dt=5
M10 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=9690 $Y=750 $dt=5
M11 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=3.404e-13 PD=1.34e-06 PS=1.86e-06 $X=10660 $Y=750 $dt=5
M12 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=11550 $Y=750 $dt=5
M13 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=3.404e-13 PD=1.34e-06 PS=1.86e-06 $X=12520 $Y=750 $dt=5
M14 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=13410 $Y=750 $dt=5
M15 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=3.404e-13 PD=1.34e-06 PS=1.86e-06 $X=14380 $Y=750 $dt=5
M16 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.84e-13 AS=2.16e-13 PD=2.56e-06 PS=1.34e-06 $X=15270 $Y=750 $dt=5
M17 6 A vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=5.79287e-13 PD=1.86506e-06 PS=3.69506e-06 $X=475 $Y=2410 $dt=6
M18 vdd3i! A 6 vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=1315 $Y=2410 $dt=6
M19 6 A vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=1865 $Y=2410 $dt=6
M20 vdd3i! A 6 vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=2705 $Y=2410 $dt=6
M21 6 A vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=3255 $Y=2410 $dt=6
M22 vdd3i! A 6 vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=4095 $Y=2410 $dt=6
M23 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=4645 $Y=2410 $dt=6
M24 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=5485 $Y=2410 $dt=6
M25 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=6035 $Y=2410 $dt=6
M26 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=6875 $Y=2410 $dt=6
M27 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=7425 $Y=2410 $dt=6
M28 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=8265 $Y=2410 $dt=6
M29 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=8815 $Y=2410 $dt=6
M30 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=9655 $Y=2410 $dt=6
M31 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=10205 $Y=2410 $dt=6
M32 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=11045 $Y=2410 $dt=6
M33 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=11595 $Y=2410 $dt=6
M34 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=12435 $Y=2410 $dt=6
M35 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=12985 $Y=2410 $dt=6
M36 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=13825 $Y=2410 $dt=6
M37 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=14375 $Y=2410 $dt=6
M38 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=1.15229e-12 AS=2.54913e-13 PD=4.89506e-06 PS=1.86506e-06 $X=15215 $Y=2410 $dt=6
.ends BUJI3VX16

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BUJI3VX0                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BUJI3VX0 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=6 EP=4 FDC=4
M0 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=3.923e-13 AS=2.016e-13 PD=2.005e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=5
M1 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=3.923e-13 PD=1.8e-06 PS=2.005e-06 $X=1735 $Y=1130 $dt=5
M2 vdd3i! A 6 vdd3i! pe3i L=3e-07 W=9e-07 AD=5.7805e-13 AS=4.32e-13 PD=2.33911e-06 PS=2.76e-06 $X=620 $Y=2410 $dt=6
M3 Q 6 vdd3i! vdd3i! pe3i L=3e-07 W=1.12e-06 AD=5.376e-13 AS=7.1935e-13 PD=3.2e-06 PS=2.91089e-06 $X=1785 $Y=2410 $dt=6
.ends BUJI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA2I1JI3VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA2I1JI3VX1 vdd3i! gnd3i! AN Q B
*.DEVICECLIMB
** N=8 EP=5 FDC=6
M0 gnd3i! AN 7 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.44754e-13 AS=2.016e-13 PD=1.25038e-06 PS=1.8e-06 $X=620 $Y=660 $dt=5
M1 8 7 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=5.18646e-13 PD=1.14e-06 PS=2.64962e-06 $X=1680 $Y=660 $dt=5
M2 Q B 8 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=1.1125e-13 PD=2.74e-06 PS=1.14e-06 $X=2280 $Y=660 $dt=5
M3 vdd3i! AN 7 vdd3i! pe3i L=3e-07 W=7e-07 AD=6.84341e-13 AS=3.36e-13 PD=3.08e-06 PS=2.36e-06 $X=620 $Y=2410 $dt=6
M4 Q 7 vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=2.7e-13 AS=9.7763e-13 PD=1.54e-06 PS=4.4e-06 $X=1510 $Y=2410 $dt=6
M5 vdd3i! B Q vdd3i! pe3i L=3e-07 W=1e-06 AD=9.7763e-13 AS=2.7e-13 PD=4.4e-06 PS=1.54e-06 $X=2350 $Y=2410 $dt=6
.ends NA2I1JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DLY1JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DLY1JI3VX1 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=8 EP=4 FDC=8
M0 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=3.591e-13 AS=2.016e-13 PD=2.13e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=5
M1 8 6 gnd3i! gnd3i! ne3i L=8e-07 W=4.2e-07 AD=2.415e-13 AS=3.591e-13 PD=1.99e-06 PS=2.13e-06 $X=1590 $Y=1400 $dt=5
M2 gnd3i! 8 7 gnd3i! ne3i L=1e-06 W=4.2e-07 AD=2.6662e-13 AS=2.016e-13 PD=1.28565e-06 PS=1.8e-06 $X=2860 $Y=660 $dt=5
M3 Q 7 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.3165e-13 AS=5.6498e-13 PD=2.75e-06 PS=2.72435e-06 $X=4625 $Y=660 $dt=5
M4 vdd3i! A 6 vdd3i! pe3i L=3e-07 W=6.7e-07 AD=4.61962e-13 AS=3.3835e-13 PD=2.62468e-06 PS=2.35e-06 $X=645 $Y=2680 $dt=6
M5 8 6 vdd3i! vdd3i! pe3i L=1e-06 W=4.2e-07 AD=2.00088e-13 AS=2.89588e-13 PD=1.76778e-06 PS=1.64532e-06 $X=1590 $Y=2680 $dt=6
M6 vdd3i! 8 7 vdd3i! pe3i L=7.5e-07 W=4.2e-07 AD=2.78313e-13 AS=2.00088e-13 PD=1.17049e-06 PS=1.76778e-06 $X=3110 $Y=3400 $dt=6
M7 Q 7 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=7.191e-13 AS=9.34337e-13 PD=3.84e-06 PS=3.92951e-06 $X=4650 $Y=2410 $dt=6
.ends DLY1JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OR4JI3VX1                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OR4JI3VX1 vdd3i! gnd3i! C D Q B A
*.DEVICECLIMB
** N=13 EP=7 FDC=12
M0 9 C gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=4.12474e-13 PD=9.6e-07 PS=2.12185e-06 $X=510 $Y=1130 $dt=5
M1 gnd3i! D 9 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=4.12474e-13 AS=1.134e-13 PD=2.12185e-06 PS=9.6e-07 $X=1400 $Y=1130 $dt=5
M2 11 9 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=8.74052e-13 PD=1.14e-06 PS=4.4963e-06 $X=2330 $Y=660 $dt=5
M3 Q 10 11 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.56e-13 AS=1.1125e-13 PD=2.64627e-06 PS=1.14e-06 $X=2930 $Y=660 $dt=5
M4 10 B gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=7.908e-13 PD=9.6e-07 PS=4.27314e-06 $X=4410 $Y=1130 $dt=5
M5 gnd3i! A 10 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=7.908e-13 AS=1.134e-13 PD=4.27314e-06 PS=9.6e-07 $X=5300 $Y=1130 $dt=5
M6 12 C 9 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=1.0625e-13 AS=4.08e-13 PD=1.1e-06 PS=2.66e-06 $X=620 $Y=2410 $dt=6
M7 vdd3i! D 12 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=6.21177e-13 AS=1.0625e-13 PD=2.08363e-06 PS=1.1e-06 $X=1170 $Y=2410 $dt=6
M8 Q 9 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.807e-13 AS=1.03042e-12 PD=1.95e-06 PS=3.45637e-06 $X=2480 $Y=2410 $dt=6
M9 vdd3i! 10 Q vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.09631e-12 AS=3.807e-13 PD=3.53124e-06 PS=1.95e-06 $X=3320 $Y=2410 $dt=6
M10 13 B vdd3i! vdd3i! pe3i L=3e-07 W=8.5e-07 AD=1.0625e-13 AS=6.60894e-13 PD=1.1e-06 PS=2.12876e-06 $X=4690 $Y=2410 $dt=6
M11 10 A 13 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=4.08e-13 AS=1.0625e-13 PD=2.66e-06 PS=1.1e-06 $X=5240 $Y=2410 $dt=6
.ends OR4JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DFRRQJI3VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DFRRQJI3VX1 vdd3i! gnd3i! RN D C Q
*.DEVICECLIMB
** N=23 EP=6 FDC=30
M0 gnd3i! 18 11 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.39017e-13 AS=2.016e-13 PD=9.16947e-07 PS=1.8e-06 $X=620 $Y=660 $dt=5
M1 8 RN gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.28952e-13 AS=2.94583e-13 PD=2.36956e-06 PS=1.94305e-06 $X=1510 $Y=660 $dt=5
M2 14 11 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.55236e-13 PD=6.7e-07 PS=1.11822e-06 $X=2340 $Y=1390 $dt=5
M3 18 9 14 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=2940 $Y=1390 $dt=5
M4 15 12 18 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.134e-13 PD=6.7e-07 PS=9.6e-07 $X=3830 $Y=1390 $dt=5
M5 8 D 15 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.835e-13 AS=5.25e-14 PD=2.19e-06 PS=6.7e-07 $X=4430 $Y=1390 $dt=5
M6 gnd3i! C 12 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.659e-13 AS=2.016e-13 PD=1.21e-06 PS=1.8e-06 $X=6060 $Y=1390 $dt=5
M7 9 12 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.95e-13 AS=1.659e-13 PD=2.23e-06 PS=1.21e-06 $X=7045 $Y=1390 $dt=5
M8 16 11 10 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=8695 $Y=1020 $dt=5
M9 19 9 16 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=9295 $Y=1020 $dt=5
M10 17 12 19 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.134e-13 PD=6.7e-07 PS=9.6e-07 $X=10185 $Y=1020 $dt=5
M11 10 13 17 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.55817e-13 AS=5.25e-14 PD=9.68244e-07 PS=6.7e-07 $X=10785 $Y=1020 $dt=5
M12 gnd3i! RN 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=6.52289e-13 AS=3.30183e-13 PD=3.3375e-06 PS=2.05176e-06 $X=11755 $Y=660 $dt=5
M13 13 19 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=3.07822e-13 PD=1.8e-06 PS=1.575e-06 $X=12560 $Y=1130 $dt=5
M14 Q 19 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=6.52289e-13 PD=2.74e-06 PS=3.3375e-06 $X=14150 $Y=660 $dt=5
M15 vdd3i! 18 11 vdd3i! pe3i L=3e-07 W=7.2e-07 AD=1.944e-13 AS=3.456e-13 PD=1.26e-06 PS=2.4e-06 $X=620 $Y=2670 $dt=6
M16 18 RN vdd3i! vdd3i! pe3i L=3e-07 W=7.2e-07 AD=3.136e-13 AS=1.944e-13 PD=2.4e-06 PS=1.26e-06 $X=1460 $Y=2670 $dt=6
M17 20 11 vdd3i! vdd3i! pe3i L=3e-07 W=4.2e-07 AD=5.25e-14 AS=5.1875e-13 PD=6.7e-07 PS=2.99e-06 $X=3080 $Y=3400 $dt=6
M18 18 12 20 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=1.21617e-13 AS=5.25e-14 PD=9.13043e-07 PS=6.7e-07 $X=3630 $Y=3400 $dt=6
M19 22 9 18 vdd3i! pe3i L=3e-07 W=9.6e-07 AD=1.2e-13 AS=2.77983e-13 PD=1.21e-06 PS=2.08696e-06 $X=4470 $Y=2860 $dt=6
M20 vdd3i! D 22 vdd3i! pe3i L=3e-07 W=9.6e-07 AD=5.00229e-13 AS=1.2e-13 PD=2.34286e-06 PS=1.21e-06 $X=5020 $Y=2860 $dt=6
M21 12 C vdd3i! vdd3i! pe3i L=3e-07 W=7.2e-07 AD=4.94875e-13 AS=3.75171e-13 PD=3.04e-06 PS=1.75714e-06 $X=6060 $Y=2860 $dt=6
M22 vdd3i! 12 9 vdd3i! pe3i L=3e-07 W=7.2e-07 AD=3.92547e-13 AS=3.528e-13 PD=1.8586e-06 PS=2.42e-06 $X=7720 $Y=2670 $dt=6
M23 23 11 vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=1.25e-13 AS=5.45203e-13 PD=1.25e-06 PS=2.5814e-06 $X=8740 $Y=2820 $dt=6
M24 19 12 23 vdd3i! pe3i L=3e-07 W=1e-06 AD=2.96338e-13 AS=1.25e-13 PD=2.19718e-06 PS=1.25e-06 $X=9290 $Y=2820 $dt=6
M25 21 9 19 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=5.25e-14 AS=1.24462e-13 PD=6.7e-07 PS=9.22817e-07 $X=10150 $Y=3235 $dt=6
M26 vdd3i! 13 21 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=4.10996e-13 AS=5.25e-14 PD=1.64789e-06 PS=6.7e-07 $X=10700 $Y=3235 $dt=6
M27 vdd3i! RN 19 vdd3i! pe3i L=3e-07 W=7.2e-07 AD=7.04565e-13 AS=2.976e-13 PD=2.82495e-06 PS=2.4e-06 $X=11900 $Y=2410 $dt=6
M28 13 19 vdd3i! vdd3i! pe3i L=3e-07 W=7.2e-07 AD=3.456e-13 AS=7.04565e-13 PD=2.4e-06 PS=2.82495e-06 $X=12740 $Y=2410 $dt=6
M29 Q 19 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=1.37977e-12 PD=3.78e-06 PS=5.5322e-06 $X=14200 $Y=2410 $dt=6
.ends DFRRQJI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: INJI3VX1                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt INJI3VX1 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=5 EP=4 FDC=2
M0 Q A gnd3i! gnd3i! ne3i L=3.5e-07 W=6e-07 AD=2.88e-13 AS=6.428e-13 PD=2.16e-06 PS=3.62e-06 $X=710 $Y=950 $dt=5
M1 Q A vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=1.0562e-12 PD=3.78e-06 PS=4.76e-06 $X=760 $Y=2410 $dt=6
.ends INJI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: INJI3VX2                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt INJI3VX2 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=5 EP=4 FDC=4
M0 Q A gnd3i! gnd3i! ne3i L=3.5e-07 W=4.8e-07 AD=1.296e-13 AS=4.408e-13 PD=1.02e-06 PS=3.52e-06 $X=500 $Y=1070 $dt=5
M1 gnd3i! A Q gnd3i! ne3i L=3.5e-07 W=4.8e-07 AD=4.408e-13 AS=1.296e-13 PD=3.52e-06 PS=1.02e-06 $X=1390 $Y=1070 $dt=5
M2 Q A vdd3i! vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=2.751e-13 AS=8.151e-13 PD=1.87971e-06 PS=4.50971e-06 $X=560 $Y=2410 $dt=6
M3 vdd3i! A Q vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=8.01e-13 AS=2.751e-13 PD=4.48971e-06 PS=1.87971e-06 $X=1400 $Y=2410 $dt=6
.ends INJI3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BUJI3VX12                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BUJI3VX12 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=6 EP=4 FDC=28
M0 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=8e-07 AD=4.148e-13 AS=3.84e-13 PD=1.98e-06 PS=2.56e-06 $X=620 $Y=750 $dt=5
M1 6 A gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=4.148e-13 PD=1.34e-06 PS=1.98e-06 $X=1710 $Y=750 $dt=5
M2 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=2600 $Y=750 $dt=5
M3 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=3.404e-13 PD=1.34e-06 PS=1.86e-06 $X=3570 $Y=750 $dt=5
M4 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=4460 $Y=750 $dt=5
M5 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=3.404e-13 PD=1.34e-06 PS=1.86e-06 $X=5430 $Y=750 $dt=5
M6 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=6320 $Y=750 $dt=5
M7 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=3.404e-13 PD=1.34e-06 PS=1.86e-06 $X=7290 $Y=750 $dt=5
M8 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.404e-13 AS=2.16e-13 PD=1.86e-06 PS=1.34e-06 $X=8180 $Y=750 $dt=5
M9 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=3.404e-13 PD=1.34e-06 PS=1.86e-06 $X=9150 $Y=750 $dt=5
M10 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.194e-13 AS=2.16e-13 PD=1.36e-06 PS=1.34e-06 $X=10040 $Y=750 $dt=5
M11 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.84e-13 AS=2.194e-13 PD=2.56e-06 PS=1.36e-06 $X=10930 $Y=750 $dt=5
M12 6 A vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=5.79287e-13 PD=1.86506e-06 PS=3.69506e-06 $X=475 $Y=2410 $dt=6
M13 vdd3i! A 6 vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=1315 $Y=2410 $dt=6
M14 6 A vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=1865 $Y=2410 $dt=6
M15 vdd3i! A 6 vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=2705 $Y=2410 $dt=6
M16 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=3255 $Y=2410 $dt=6
M17 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=4095 $Y=2410 $dt=6
M18 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=4645 $Y=2410 $dt=6
M19 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=5485 $Y=2410 $dt=6
M20 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=6035 $Y=2410 $dt=6
M21 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=6875 $Y=2410 $dt=6
M22 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=7425 $Y=2410 $dt=6
M23 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=8265 $Y=2410 $dt=6
M24 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=8815 $Y=2410 $dt=6
M25 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.83187e-13 AS=2.54913e-13 PD=1.86506e-06 PS=1.86506e-06 $X=9655 $Y=2410 $dt=6
M26 Q 6 vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=2.83187e-13 PD=1.86506e-06 PS=1.86506e-06 $X=10205 $Y=2410 $dt=6
M27 vdd3i! 6 Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=8.53088e-13 AS=2.54913e-13 PD=4.55506e-06 PS=1.86506e-06 $X=11045 $Y=2410 $dt=6
.ends BUJI3VX12

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ON22JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ON22JI3VX1 vdd3i! gnd3i! D C Q A B
*.DEVICECLIMB
** N=11 EP=7 FDC=8
M0 gnd3i! D 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.494e-13 AS=4.272e-13 PD=1.86e-06 PS=2.74e-06 $X=720 $Y=660 $dt=5
M1 9 C gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=3.494e-13 PD=1.43e-06 PS=1.86e-06 $X=1690 $Y=660 $dt=5
M2 Q A 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=2580 $Y=660 $dt=5
M3 9 B Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.666e-13 AS=2.403e-13 PD=2.84e-06 PS=1.43e-06 $X=3470 $Y=660 $dt=5
M4 10 D vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=8.802e-13 PD=1.66e-06 PS=4.56e-06 $X=1120 $Y=2410 $dt=6
M5 Q C 10 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.807e-13 AS=1.7625e-13 PD=1.95e-06 PS=1.66e-06 $X=1670 $Y=2410 $dt=6
M6 11 A Q vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=3.807e-13 PD=1.66e-06 PS=1.95e-06 $X=2510 $Y=2410 $dt=6
M7 vdd3i! B 11 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=8.802e-13 AS=1.7625e-13 PD=4.56e-06 PS=1.66e-06 $X=3060 $Y=2410 $dt=6
.ends ON22JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AN31JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AN31JI3VX1 vdd3i! gnd3i! A B C Q D
*.DEVICECLIMB
** N=11 EP=7 FDC=8
M0 9 A gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.335e-13 AS=6.098e-13 PD=1.19e-06 PS=3.52e-06 $X=660 $Y=660 $dt=5
M1 10 B 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.35725e-13 AS=1.335e-13 PD=1.195e-06 PS=1.19e-06 $X=1310 $Y=660 $dt=5
M2 Q C 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.0257e-13 AS=1.35725e-13 PD=1.8043e-06 PS=1.195e-06 $X=1965 $Y=660 $dt=5
M3 gnd3i! D Q gnd3i! ne3i L=3.5e-07 W=5.75e-07 AD=5.783e-13 AS=1.9548e-13 PD=3.52e-06 PS=1.1657e-06 $X=2910 $Y=975 $dt=5
M4 11 A vdd3i! vdd3i! pe3i L=3.00061e-07 W=1.44471e-06 AD=3.0525e-13 AS=5.93475e-13 PD=1.86471e-06 PS=3.72971e-06 $X=525 $Y=2425 $dt=6
M5 vdd3i! B 11 vdd3i! pe3i L=3.00061e-07 W=1.44471e-06 AD=4.42387e-13 AS=3.0525e-13 PD=2.08971e-06 PS=1.86471e-06 $X=1365 $Y=2425 $dt=6
M6 11 C vdd3i! vdd3i! pe3i L=3.00061e-07 W=1.44471e-06 AD=2.6565e-13 AS=4.42387e-13 PD=1.86471e-06 PS=2.08971e-06 $X=2310 $Y=2425 $dt=6
M7 Q D 11 vdd3i! pe3i L=3.00061e-07 W=1.44471e-06 AD=7.2375e-13 AS=2.6565e-13 PD=3.85971e-06 PS=1.86471e-06 $X=2910 $Y=2425 $dt=6
.ends AN31JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO3JI3VX0                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO3JI3VX0 vdd3i! gnd3i! C Q B A
*.DEVICECLIMB
** N=9 EP=6 FDC=6
M0 Q C gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.75467e-13 PD=9.6e-07 PS=2.95333e-06 $X=615 $Y=1130 $dt=5
M1 gnd3i! B Q gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.75467e-13 AS=1.134e-13 PD=2.95333e-06 PS=9.6e-07 $X=1505 $Y=1130 $dt=5
M2 Q A gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=5.75467e-13 PD=1.8e-06 PS=2.95333e-06 $X=2390 $Y=1130 $dt=5
M3 8 C vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=1.55e-13 AS=1.3584e-12 PD=1.31e-06 PS=5.15e-06 $X=955 $Y=2410 $dt=6
M4 9 B 8 vdd3i! pe3i L=3e-07 W=1e-06 AD=1.55e-13 AS=1.55e-13 PD=1.31e-06 PS=1.31e-06 $X=1565 $Y=2410 $dt=6
M5 Q A 9 vdd3i! pe3i L=3e-07 W=1e-06 AD=4.8e-13 AS=1.55e-13 PD=2.96e-06 PS=1.31e-06 $X=2175 $Y=2410 $dt=6
.ends NO3JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OR4JI3VX2                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OR4JI3VX2 vdd3i! gnd3i! C D Q B A
*.DEVICECLIMB
** N=14 EP=7 FDC=16
M0 9 C gnd3i! gnd3i! ne3i L=3.5e-07 W=7e-07 AD=1.9155e-13 AS=3.417e-13 PD=1.255e-06 PS=2.39e-06 $X=620 $Y=660 $dt=5
M1 gnd3i! D 9 gnd3i! ne3i L=3.5e-07 W=7e-07 AD=2.07711e-13 AS=1.9155e-13 PD=1.27673e-06 PS=1.255e-06 $X=1510 $Y=660 $dt=5
M2 11 9 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=2.64089e-13 PD=1.14e-06 PS=1.62327e-06 $X=2420 $Y=660 $dt=5
M3 Q 10 11 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=1.1125e-13 PD=1.43e-06 PS=1.14e-06 $X=3020 $Y=660 $dt=5
M4 12 10 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.2015e-13 AS=2.403e-13 PD=1.16e-06 PS=1.43e-06 $X=3910 $Y=660 $dt=5
M5 gnd3i! 9 12 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.54126e-13 AS=1.2015e-13 PD=1.60088e-06 PS=1.16e-06 $X=4530 $Y=660 $dt=5
M6 10 B gnd3i! gnd3i! ne3i L=3.5e-07 W=7e-07 AD=1.9155e-13 AS=1.99874e-13 PD=1.255e-06 PS=1.25912e-06 $X=5420 $Y=660 $dt=5
M7 gnd3i! A 10 gnd3i! ne3i L=3.5e-07 W=7e-07 AD=3.417e-13 AS=1.9155e-13 PD=2.39e-06 PS=1.255e-06 $X=6310 $Y=660 $dt=5
M8 13 C 9 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=6.768e-13 PD=1.66e-06 PS=3.78e-06 $X=710 $Y=2410 $dt=6
M9 vdd3i! D 13 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=5.47043e-13 AS=1.7625e-13 PD=2.41704e-06 PS=1.66e-06 $X=1260 $Y=2410 $dt=6
M10 Q 9 vdd3i! vdd3i! pe3i L=2.99799e-07 W=1.41828e-06 AD=3.622e-13 AS=5.50257e-13 PD=1.93828e-06 PS=2.43124e-06 $X=2210 $Y=2410 $dt=6
M11 vdd3i! 10 Q vdd3i! pe3i L=2.99799e-07 W=1.41828e-06 AD=4.987e-13 AS=3.622e-13 PD=2.36828e-06 PS=1.93828e-06 $X=3050 $Y=2410 $dt=6
M12 Q 10 vdd3i! vdd3i! pe3i L=2.99799e-07 W=1.41828e-06 AD=3.622e-13 AS=4.987e-13 PD=1.93828e-06 PS=2.36828e-06 $X=3930 $Y=2410 $dt=6
M13 vdd3i! 9 Q vdd3i! pe3i L=2.99799e-07 W=1.41828e-06 AD=5.8556e-13 AS=3.622e-13 PD=2.47136e-06 PS=1.93828e-06 $X=4770 $Y=2410 $dt=6
M14 14 B vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=5.8214e-13 PD=1.66e-06 PS=2.45692e-06 $X=5760 $Y=2410 $dt=6
M15 10 A 14 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=6310 $Y=2410 $dt=6
.ends OR4JI3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: HAJI3VX1                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt HAJI3VX1 vdd3i! gnd3i! S B A CO
*.DEVICECLIMB
** N=12 EP=6 FDC=14
M0 gnd3i! 9 S gnd3i! ne3i L=3.49889e-07 W=8.98284e-07 AD=4.998e-13 AS=4.174e-13 PD=3.41456e-06 PS=2.72828e-06 $X=600 $Y=660 $dt=5
M1 gnd3i! A 8 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=3.52e-13 PD=1.43e-06 PS=2.74e-06 $X=2070 $Y=660 $dt=5
M2 8 B gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.70969e-13 AS=2.403e-13 PD=1.71986e-06 PS=1.43e-06 $X=2960 $Y=660 $dt=5
M3 9 11 8 gnd3i! ne3i L=3.5e-07 W=5.9e-07 AD=3.632e-13 AS=1.79631e-13 PD=2.84284e-06 PS=1.14014e-06 $X=3850 $Y=960 $dt=5
M4 gnd3i! 11 CO gnd3i! ne3i L=3.5e-07 W=5.5e-07 AD=1.56292e-13 AS=2.4195e-13 PD=1.09236e-06 PS=2.03071e-06 $X=5380 $Y=1000 $dt=5
M5 10 B gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=2.52908e-13 PD=1.14e-06 PS=1.76764e-06 $X=6270 $Y=660 $dt=5
M6 11 A 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=1.1125e-13 PD=2.74e-06 PS=1.14e-06 $X=6870 $Y=660 $dt=5
M7 vdd3i! 9 S vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.07833e-13 AS=7.1205e-13 PD=2.97939e-06 PS=3.83e-06 $X=645 $Y=2410 $dt=6
M8 12 A vdd3i! vdd3i! pe3i L=3e-07 W=8.9e-07 AD=1.335e-13 AS=3.83667e-13 PD=1.19e-06 PS=1.88061e-06 $X=1615 $Y=2630 $dt=6
M9 9 B 12 vdd3i! pe3i L=3e-07 W=8.9e-07 AD=4.9565e-13 AS=1.335e-13 PD=2.12e-06 PS=1.19e-06 $X=2215 $Y=2630 $dt=6
M10 vdd3i! 11 9 vdd3i! pe3i L=3e-07 W=8.9e-07 AD=4.8925e-13 AS=4.9565e-13 PD=3.49e-06 PS=2.12e-06 $X=3525 $Y=2630 $dt=6
M11 vdd3i! 11 CO vdd3i! pe3i L=3e-07 W=1.11e-06 AD=4.3695e-13 AS=4.7415e-13 PD=2.09e-06 PS=3.23e-06 $X=4995 $Y=2410 $dt=6
M12 11 B vdd3i! vdd3i! pe3i L=3e-07 W=1.11e-06 AD=3.2745e-13 AS=4.3695e-13 PD=1.7e-06 PS=2.09e-06 $X=5965 $Y=2410 $dt=6
M13 vdd3i! A 11 vdd3i! pe3i L=3e-07 W=1.11e-06 AD=8.7795e-13 AS=3.2745e-13 PD=4.61e-06 PS=1.7e-06 $X=6855 $Y=2410 $dt=6
.ends HAJI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DLY4JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DLY4JI3VX1 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=12 EP=4 FDC=12
M0 gnd3i! A 10 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.323e-13 AS=2.016e-13 PD=1.05e-06 PS=1.8e-06 $X=620 $Y=660 $dt=5
M1 7 10 gnd3i! gnd3i! ne3i L=1.8e-06 W=4.2e-07 AD=1.736e-13 AS=1.323e-13 PD=1.58e-06 PS=1.05e-06 $X=1600 $Y=660 $dt=5
M2 7 10 6 gnd3i! ne3i L=1.8e-06 W=4.2e-07 AD=1.736e-13 AS=2.00088e-13 PD=1.58e-06 PS=1.76778e-06 $X=1600 $Y=1360 $dt=5
M3 gnd3i! 6 8 gnd3i! ne3i L=1.1e-06 W=4.2e-07 AD=4.30324e-13 AS=2.16e-13 PD=1.75053e-06 PS=1.66e-06 $X=4630 $Y=660 $dt=5
M4 9 6 8 gnd3i! ne3i L=1.1e-06 W=4.2e-07 AD=2.00088e-13 AS=2.16e-13 PD=1.76778e-06 PS=1.66e-06 $X=4630 $Y=1400 $dt=5
M5 Q 9 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.4055e-13 AS=9.11876e-13 PD=2.77e-06 PS=3.70947e-06 $X=7220 $Y=660 $dt=5
M6 vdd3i! A 10 vdd3i! pe3i L=3e-07 W=7e-07 AD=5.26875e-13 AS=3.535e-13 PD=3.30625e-06 PS=2.41e-06 $X=645 $Y=2680 $dt=6
M7 11 10 6 vdd3i! pe3i L=1.2e-06 W=4.2e-07 AD=1.674e-13 AS=2.016e-13 PD=1.56e-06 PS=1.8e-06 $X=2100 $Y=2680 $dt=6
M8 11 10 vdd3i! vdd3i! pe3i L=1.2e-06 W=4.2e-07 AD=1.674e-13 AS=3.16125e-13 PD=1.56e-06 PS=1.98375e-06 $X=2100 $Y=3400 $dt=6
M9 9 6 12 vdd3i! pe3i L=1.9e-06 W=4.2e-07 AD=2.016e-13 AS=1.674e-13 PD=1.8e-06 PS=1.56e-06 $X=4220 $Y=2680 $dt=6
M10 vdd3i! 6 12 vdd3i! pe3i L=1.9e-06 W=4.2e-07 AD=2.6367e-13 AS=1.674e-13 PD=1.32426e-06 PS=1.56e-06 $X=4220 $Y=3400 $dt=6
M11 Q 9 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=7.332e-13 AS=8.8518e-13 PD=3.86e-06 PS=4.44574e-06 $X=7245 $Y=2410 $dt=6
.ends DLY4JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO2I1JI3VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO2I1JI3VX1 vdd3i! gnd3i! AN Q B
*.DEVICECLIMB
** N=8 EP=5 FDC=6
M0 gnd3i! AN 7 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.78131e-13 AS=2.016e-13 PD=1.19267e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=5
M1 Q 7 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.4285e-13 AS=3.77469e-13 PD=1.445e-06 PS=2.52733e-06 $X=1460 $Y=660 $dt=5
M2 gnd3i! B Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=6.098e-13 AS=2.4285e-13 PD=3.52e-06 PS=1.445e-06 $X=2350 $Y=660 $dt=5
M3 vdd3i! AN 7 vdd3i! pe3i L=3e-07 W=7e-07 AD=4.32009e-13 AS=3.36e-13 PD=1.71185e-06 PS=2.36e-06 $X=620 $Y=2410 $dt=6
M4 8 7 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=8.70191e-13 PD=1.66e-06 PS=3.44815e-06 $X=1740 $Y=2410 $dt=6
M5 Q B 8 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=1.7625e-13 PD=3.78e-06 PS=1.66e-06 $X=2290 $Y=2410 $dt=6
.ends NO2I1JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AO22JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AO22JI3VX1 vdd3i! gnd3i! B A C D Q
*.DEVICECLIMB
** N=12 EP=7 FDC=10
M0 9 B gnd3i! gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=7e-14 AS=5.768e-13 PD=8.1e-07 PS=3.52e-06 $X=660 $Y=990 $dt=5
M1 11 A 9 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=1.68e-13 AS=7e-14 PD=1.16e-06 PS=8.1e-07 $X=1260 $Y=990 $dt=5
M2 10 C 11 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=7e-14 AS=1.68e-13 PD=8.1e-07 PS=1.16e-06 $X=2210 $Y=990 $dt=5
M3 gnd3i! D 10 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=3.96017e-13 AS=7e-14 PD=1.66069e-06 PS=8.1e-07 $X=2810 $Y=990 $dt=5
M4 Q 11 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=6.29383e-13 PD=2.74e-06 PS=2.63931e-06 $X=4070 $Y=660 $dt=5
M5 vdd3i! B 12 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=2.295e-13 AS=4.868e-13 PD=1.39e-06 PS=3.75e-06 $X=460 $Y=2490 $dt=6
M6 12 A vdd3i! vdd3i! pe3i L=3e-07 W=8.5e-07 AD=4.868e-13 AS=2.295e-13 PD=3.75e-06 PS=1.39e-06 $X=1300 $Y=2490 $dt=6
M7 11 C 12 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=2.295e-13 AS=4.868e-13 PD=1.39e-06 PS=3.75e-06 $X=2020 $Y=2490 $dt=6
M8 12 D 11 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=4.868e-13 AS=2.295e-13 PD=3.75e-06 PS=1.39e-06 $X=2860 $Y=2490 $dt=6
M9 Q 11 vdd3i! vdd3i! pe3i L=3.01705e-07 W=1.47627e-06 AD=5.312e-13 AS=7.778e-13 PD=3.68627e-06 PS=4.46627e-06 $X=4120 $Y=2410 $dt=6
.ends AO22JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BUJI3VX6                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BUJI3VX6 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=6 EP=4 FDC=14
M0 6 A gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=2.16e-13 AS=6.008e-13 PD=1.34e-06 PS=3.52e-06 $X=660 $Y=750 $dt=5
M1 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=8e-07 AD=5.84805e-13 AS=2.16e-13 PD=2.17751e-06 PS=1.34e-06 $X=1550 $Y=750 $dt=5
M2 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=6.50595e-13 PD=1.43e-06 PS=2.42249e-06 $X=2960 $Y=660 $dt=5
M3 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.494e-13 AS=2.403e-13 PD=1.86e-06 PS=1.43e-06 $X=3850 $Y=660 $dt=5
M4 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=3.494e-13 PD=1.43e-06 PS=1.86e-06 $X=4820 $Y=660 $dt=5
M5 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=6.098e-13 AS=2.403e-13 PD=3.52e-06 PS=1.43e-06 $X=5710 $Y=660 $dt=5
M6 6 A vdd3i! vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=2.751e-13 AS=6.3285e-13 PD=1.87971e-06 PS=3.75971e-06 $X=525 $Y=2410 $dt=6
M7 vdd3i! A 6 vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=3.7905e-13 AS=2.751e-13 PD=1.98971e-06 PS=1.87971e-06 $X=1365 $Y=2410 $dt=6
M8 Q 6 vdd3i! vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=2.751e-13 AS=3.7905e-13 PD=1.87971e-06 PS=1.98971e-06 $X=2075 $Y=2410 $dt=6
M9 vdd3i! 6 Q vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=3.3675e-13 AS=2.751e-13 PD=1.92971e-06 PS=1.87971e-06 $X=2915 $Y=2410 $dt=6
M10 Q 6 vdd3i! vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=2.751e-13 AS=3.3675e-13 PD=1.87971e-06 PS=1.92971e-06 $X=3565 $Y=2410 $dt=6
M11 vdd3i! 6 Q vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=3.3675e-13 AS=2.751e-13 PD=1.92971e-06 PS=1.87971e-06 $X=4405 $Y=2410 $dt=6
M12 Q 6 vdd3i! vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=2.751e-13 AS=3.3675e-13 PD=1.87971e-06 PS=1.92971e-06 $X=5055 $Y=2410 $dt=6
M13 vdd3i! 6 Q vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=6.3285e-13 AS=2.751e-13 PD=3.75971e-06 PS=1.87971e-06 $X=5895 $Y=2410 $dt=6
.ends BUJI3VX6

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ON31JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ON31JI3VX1 vdd3i! gnd3i! A B C Q D
*.DEVICECLIMB
** N=11 EP=7 FDC=8
M0 9 A gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=6.098e-13 PD=1.43e-06 PS=3.52e-06 $X=660 $Y=660 $dt=5
M1 gnd3i! B 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.494e-13 AS=2.403e-13 PD=1.86e-06 PS=1.43e-06 $X=1550 $Y=660 $dt=5
M2 9 C gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=3.494e-13 PD=1.43e-06 PS=1.86e-06 $X=2520 $Y=660 $dt=5
M3 Q D 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=2.403e-13 PD=2.74e-06 PS=1.43e-06 $X=3410 $Y=660 $dt=5
M4 10 A vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.1855e-13 AS=9.066e-13 PD=1.72e-06 PS=4.59e-06 $X=1145 $Y=2410 $dt=6
M5 11 B 10 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.1855e-13 AS=2.1855e-13 PD=1.72e-06 PS=1.72e-06 $X=1755 $Y=2410 $dt=6
M6 Q C 11 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=5.30442e-13 AS=2.1855e-13 PD=2.60067e-06 PS=1.72e-06 $X=2365 $Y=2410 $dt=6
M7 vdd3i! D Q vdd3i! pe3i L=3e-07 W=8.4e-07 AD=1.1576e-12 AS=3.16008e-13 PD=4.94e-06 PS=1.54933e-06 $X=3330 $Y=2410 $dt=6
.ends ON31JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EO3JI3VX1                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EO3JI3VX1 vdd3i! gnd3i! C B A Q
*.DEVICECLIMB
** N=16 EP=6 FDC=20
M0 8 C gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.628e-13 PD=9.6e-07 PS=3.52e-06 $X=660 $Y=1130 $dt=5
M1 gnd3i! B 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.30196e-13 AS=1.134e-13 PD=1.36723e-06 PS=9.6e-07 $X=1550 $Y=1130 $dt=5
M2 10 C gnd3i! gnd3i! ne3i L=3.5e-07 W=5.2e-07 AD=6.5e-14 AS=2.85004e-13 PD=7.7e-07 PS=1.69277e-06 $X=2910 $Y=1030 $dt=5
M3 12 B 10 gnd3i! ne3i L=3.5e-07 W=5.2e-07 AD=1.404e-13 AS=6.5e-14 PD=1.06e-06 PS=7.7e-07 $X=3510 $Y=1030 $dt=5
M4 gnd3i! 8 12 gnd3i! ne3i L=3.5e-07 W=5.2e-07 AD=8.05779e-13 AS=1.404e-13 PD=2.83787e-06 PS=1.06e-06 $X=4400 $Y=1030 $dt=5
M5 9 12 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=6.50821e-13 PD=9.6e-07 PS=2.29213e-06 $X=6075 $Y=1130 $dt=5
M6 gnd3i! A 9 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.90537e-13 AS=1.134e-13 PD=1.53255e-06 PS=9.6e-07 $X=6965 $Y=1130 $dt=5
M7 11 A gnd3i! gnd3i! ne3i L=3.5e-07 W=5.2e-07 AD=6.5e-14 AS=3.59713e-13 PD=7.7e-07 PS=1.89745e-06 $X=8140 $Y=1030 $dt=5
M8 Q 12 11 gnd3i! ne3i L=3.5e-07 W=5.2e-07 AD=1.404e-13 AS=6.5e-14 PD=1.06e-06 PS=7.7e-07 $X=8740 $Y=1030 $dt=5
M9 gnd3i! 9 Q gnd3i! ne3i L=3.5e-07 W=5.2e-07 AD=5.728e-13 AS=1.404e-13 PD=3.52e-06 PS=1.06e-06 $X=9630 $Y=1030 $dt=5
M10 15 C vdd3i! vdd3i! pe3i L=3e-07 W=1.3e-06 AD=1.95e-13 AS=6.603e-13 PD=1.6e-06 PS=3.63e-06 $X=645 $Y=2520 $dt=6
M11 8 B 15 vdd3i! pe3i L=3e-07 W=1.3e-06 AD=5.157e-13 AS=1.95e-13 PD=3.61e-06 PS=1.6e-06 $X=1245 $Y=2520 $dt=6
M12 vdd3i! C 14 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.1595e-13 AS=5.8645e-13 PD=2e-06 PS=3.83e-06 $X=2675 $Y=2410 $dt=6
M13 14 B vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.1595e-13 AS=4.1595e-13 PD=2e-06 PS=2e-06 $X=3565 $Y=2410 $dt=6
M14 12 8 14 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=5.6965e-13 AS=4.1595e-13 PD=3.83e-06 PS=2e-06 $X=4455 $Y=2410 $dt=6
M15 16 12 vdd3i! vdd3i! pe3i L=3e-07 W=1.3e-06 AD=1.95e-13 AS=5.301e-13 PD=1.6e-06 PS=3.61e-06 $X=5885 $Y=2410 $dt=6
M16 9 A 16 vdd3i! pe3i L=3e-07 W=1.3e-06 AD=5.157e-13 AS=1.95e-13 PD=3.61e-06 PS=1.6e-06 $X=6485 $Y=2410 $dt=6
M17 vdd3i! A 13 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.1595e-13 AS=5.8645e-13 PD=2e-06 PS=3.83e-06 $X=7915 $Y=2410 $dt=6
M18 13 12 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.1595e-13 AS=4.1595e-13 PD=2e-06 PS=2e-06 $X=8805 $Y=2410 $dt=6
M19 Q 9 13 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=7.1205e-13 AS=4.1595e-13 PD=3.83e-06 PS=2e-06 $X=9695 $Y=2410 $dt=6
.ends EO3JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: BUJI3VX2                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt BUJI3VX2 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=6 EP=4 FDC=6
M0 gnd3i! A 6 gnd3i! ne3i L=3.5e-07 W=6e-07 AD=2.96727e-13 AS=2.88e-13 PD=1.69091e-06 PS=2.16e-06 $X=620 $Y=950 $dt=5
M1 Q 6 gnd3i! gnd3i! ne3i L=3.5e-07 W=7.2e-07 AD=2.016e-13 AS=3.56073e-13 PD=1.512e-06 PS=2.02909e-06 $X=1590 $Y=830 $dt=5
M2 gnd3i! 6 Q gnd3i! ne3i L=3.5e-07 W=4.8e-07 AD=4.648e-13 AS=1.344e-13 PD=3.52e-06 PS=1.008e-06 $X=2480 $Y=1070 $dt=5
M3 vdd3i! A 6 vdd3i! pe3i L=3e-07 W=1.1e-06 AD=5.39943e-13 AS=5.28e-13 PD=2.20442e-06 PS=3.16e-06 $X=620 $Y=2410 $dt=6
M4 Q 6 vdd3i! vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=2.751e-13 AS=7.16507e-13 PD=1.87971e-06 PS=2.92528e-06 $X=1640 $Y=2410 $dt=6
M5 vdd3i! 6 Q vdd3i! pe3i L=3.00472e-07 W=1.45971e-06 AD=8.6265e-13 AS=2.751e-13 PD=4.56971e-06 PS=1.87971e-06 $X=2480 $Y=2410 $dt=6
.ends BUJI3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: INJI3VX3                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt INJI3VX3 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=5 EP=4 FDC=5
M0 Q A gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=7.586e-13 PD=1.43e-06 PS=3.76e-06 $X=780 $Y=660 $dt=5
M1 gnd3i! A Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=7.586e-13 AS=2.403e-13 PD=3.76e-06 PS=1.43e-06 $X=1670 $Y=660 $dt=5
M2 Q A vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.54913e-13 AS=6.12287e-13 PD=1.86506e-06 PS=3.78506e-06 $X=490 $Y=2410 $dt=6
M3 vdd3i! A Q vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=2.86587e-13 AS=2.54913e-13 PD=1.88506e-06 PS=1.86506e-06 $X=1330 $Y=2410 $dt=6
M4 Q A vdd3i! vdd3i! pe3i L=3.00566e-07 W=1.47006e-06 AD=5.51013e-13 AS=2.86587e-13 PD=3.69506e-06 PS=1.88506e-06 $X=1880 $Y=2410 $dt=6
.ends INJI3VX3

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA3I2JI3VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA3I2JI3VX1 vdd3i! gnd3i! AN BN C Q
*.DEVICECLIMB
** N=10 EP=6 FDC=8
M0 8 AN gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=4.00432e-13 PD=9.6e-07 PS=2.10243e-06 $X=540 $Y=1130 $dt=5
M1 gnd3i! BN 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=4.00432e-13 AS=1.134e-13 PD=2.10243e-06 PS=9.6e-07 $X=1430 $Y=1130 $dt=5
M2 9 C gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=8.48535e-13 PD=1.14e-06 PS=4.45514e-06 $X=2290 $Y=660 $dt=5
M3 Q 8 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.806e-13 AS=1.1125e-13 PD=2.86e-06 PS=1.14e-06 $X=2890 $Y=660 $dt=5
M4 10 AN 8 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=1.0625e-13 AS=4.08e-13 PD=1.1e-06 PS=2.66e-06 $X=620 $Y=2410 $dt=6
M5 vdd3i! BN 10 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=7.38476e-13 AS=1.0625e-13 PD=3.31526e-06 PS=1.1e-06 $X=1170 $Y=2410 $dt=6
M6 vdd3i! C Q vdd3i! pe3i L=3.00037e-07 W=1.00071e-06 AD=8.69412e-13 AS=2.376e-13 PD=3.90308e-06 PS=1.49071e-06 $X=2170 $Y=2410 $dt=6
M7 Q 8 vdd3i! vdd3i! pe3i L=3.00037e-07 W=1.00071e-06 AD=2.376e-13 AS=8.69412e-13 PD=1.49071e-06 PS=3.90308e-06 $X=3010 $Y=2410 $dt=6
.ends NA3I2JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EN3JI3VX1                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EN3JI3VX1 vdd3i! gnd3i! C B A Q
*.DEVICECLIMB
** N=16 EP=6 FDC=20
M0 10 C gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=2.016e-13 PD=9.6e-07 PS=1.8e-06 $X=620 $Y=1030 $dt=5
M1 gnd3i! B 10 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.97668e-13 AS=1.134e-13 PD=1.24213e-06 PS=9.6e-07 $X=1510 $Y=1030 $dt=5
M2 11 C gnd3i! gnd3i! ne3i L=3.5e-07 W=5.2e-07 AD=6.5e-14 AS=2.44732e-13 PD=7.7e-07 PS=1.53787e-06 $X=2730 $Y=930 $dt=5
M3 12 B 11 gnd3i! ne3i L=3.5e-07 W=5.2e-07 AD=1.404e-13 AS=6.5e-14 PD=1.06e-06 PS=7.7e-07 $X=3330 $Y=930 $dt=5
M4 gnd3i! 10 12 gnd3i! ne3i L=3.5e-07 W=5.2e-07 AD=5.308e-13 AS=1.404e-13 PD=3.32e-06 PS=1.06e-06 $X=4220 $Y=930 $dt=5
M5 13 12 9 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=5850 $Y=970 $dt=5
M6 gnd3i! A 13 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=6450 $Y=970 $dt=5
M7 8 A gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=1.134e-13 PD=9.6e-07 PS=9.6e-07 $X=7340 $Y=970 $dt=5
M8 gnd3i! 12 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=3.965e-13 AS=1.134e-13 PD=3.17071e-06 PS=9.6e-07 $X=8230 $Y=970 $dt=5
M9 Q 9 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=2.0035e-13 PD=1.8e-06 PS=1.77071e-06 $X=9670 $Y=1130 $dt=5
M10 15 C vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.115e-13 AS=7.1585e-13 PD=1.71e-06 PS=3.85e-06 $X=645 $Y=2410 $dt=6
M11 10 B 15 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=5.5365e-13 AS=2.115e-13 PD=3.83e-06 PS=1.71e-06 $X=1245 $Y=2410 $dt=6
M12 vdd3i! C 14 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.23e-13 AS=5.8645e-13 PD=2.01e-06 PS=3.83e-06 $X=2675 $Y=2410 $dt=6
M13 14 B vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.1595e-13 AS=4.23e-13 PD=2e-06 PS=2.01e-06 $X=3575 $Y=2410 $dt=6
M14 12 10 14 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=7.1205e-13 AS=4.1595e-13 PD=3.83e-06 PS=2e-06 $X=4465 $Y=2410 $dt=6
M15 9 12 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.1595e-13 AS=9.1545e-13 PD=2e-06 PS=4.61e-06 $X=6095 $Y=2410 $dt=6
M16 vdd3i! A 9 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.956e-13 AS=4.1595e-13 PD=2.63e-06 PS=2e-06 $X=6985 $Y=2410 $dt=6
M17 16 A vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.115e-13 AS=6.956e-13 PD=1.71e-06 PS=2.63e-06 $X=8155 $Y=2410 $dt=6
M18 Q 12 16 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.66787e-13 AS=2.115e-13 PD=2.36668e-06 PS=1.71e-06 $X=8755 $Y=2410 $dt=6
M19 vdd3i! 9 Q vdd3i! pe3i L=3e-07 W=9.85e-07 AD=8.62325e-13 AS=3.26088e-13 PD=4.61e-06 PS=1.65332e-06 $X=9655 $Y=2410 $dt=6
.ends EN3JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: SDFRRQJI3VX1                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt SDFRRQJI3VX1 vdd3i! gnd3i! SE SD RN D C Q
*.DEVICECLIMB
** N=31 EP=8 FDC=39
M0 gnd3i! SE 14 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.11575e-13 AS=2.016e-13 PD=1.6275e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=5
M1 10 RN gnd3i! gnd3i! ne3i L=3.5e-07 W=5.4e-07 AD=2.079e-13 AS=2.72025e-13 PD=1.4625e-06 PS=2.0925e-06 $X=1410 $Y=660 $dt=5
M2 17 SE 10 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.617e-13 PD=6.7e-07 PS=1.1375e-06 $X=2340 $Y=960 $dt=5
M3 11 SD 17 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.163e-13 AS=5.25e-14 PD=1.45e-06 PS=6.7e-07 $X=2940 $Y=960 $dt=5
M4 18 D 11 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=2.163e-13 PD=6.7e-07 PS=1.45e-06 $X=3910 $Y=1000 $dt=5
M5 10 14 18 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=5.25e-14 PD=1.8e-06 PS=6.7e-07 $X=4510 $Y=1000 $dt=5
M6 gnd3i! 23 22 gnd3i! ne3i L=3.5e-07 W=7.2e-07 AD=3.01862e-13 AS=3.456e-13 PD=1.65084e-06 PS=2.4e-06 $X=6100 $Y=1090 $dt=5
M7 12 RN gnd3i! gnd3i! ne3i L=3.5e-07 W=8.85e-07 AD=2.20538e-13 AS=3.71038e-13 PD=1.77e-06 PS=2.02916e-06 $X=7070 $Y=925 $dt=5
M8 19 22 12 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.04662e-13 PD=6.7e-07 PS=8.4e-07 $X=7840 $Y=1390 $dt=5
M9 23 16 19 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=8440 $Y=1390 $dt=5
M10 11 15 23 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=1.134e-13 PD=1.8e-06 PS=9.6e-07 $X=9330 $Y=1390 $dt=5
M11 gnd3i! C 15 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.722e-13 AS=2.016e-13 PD=1.24e-06 PS=1.8e-06 $X=10920 $Y=1390 $dt=5
M12 16 15 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=1.722e-13 PD=1.8e-06 PS=1.24e-06 $X=11930 $Y=1390 $dt=5
M13 20 22 13 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=2.016e-13 PD=6.7e-07 PS=1.8e-06 $X=13520 $Y=1020 $dt=5
M14 24 16 20 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=14120 $Y=1020 $dt=5
M15 21 15 24 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.134e-13 PD=6.7e-07 PS=9.6e-07 $X=15010 $Y=1020 $dt=5
M16 13 25 21 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.47785e-13 AS=5.25e-14 PD=9.42595e-07 PS=6.7e-07 $X=15610 $Y=1020 $dt=5
M17 gnd3i! RN 13 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.9815e-13 AS=3.13165e-13 PD=1.56e-06 PS=1.9974e-06 $X=16540 $Y=660 $dt=5
M18 25 24 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=2.9815e-13 PD=2.74e-06 PS=1.56e-06 $X=17560 $Y=660 $dt=5
M19 Q 24 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=6.098e-13 PD=2.74e-06 PS=3.52e-06 $X=19190 $Y=660 $dt=5
M20 vdd3i! SE 14 vdd3i! pe3i L=3e-07 W=7.2e-07 AD=5.776e-13 AS=3.456e-13 PD=2.10667e-06 PS=2.4e-06 $X=620 $Y=2800 $dt=6
M21 27 14 vdd3i! vdd3i! pe3i L=3e-07 W=9e-07 AD=1.125e-13 AS=7.22e-13 PD=1.15e-06 PS=2.63333e-06 $X=2030 $Y=2620 $dt=6
M22 26 SD 27 vdd3i! pe3i L=3e-07 W=9e-07 AD=2.43e-13 AS=1.125e-13 PD=1.44e-06 PS=1.15e-06 $X=2580 $Y=2620 $dt=6
M23 28 D 26 vdd3i! pe3i L=3e-07 W=9e-07 AD=1.125e-13 AS=2.43e-13 PD=1.15e-06 PS=1.44e-06 $X=3420 $Y=2620 $dt=6
M24 vdd3i! SE 28 vdd3i! pe3i L=3e-07 W=9e-07 AD=3.80558e-13 AS=1.125e-13 PD=1.98274e-06 PS=1.15e-06 $X=3970 $Y=2620 $dt=6
M25 22 23 vdd3i! vdd3i! pe3i L=3e-07 W=1.07e-06 AD=5.136e-13 AS=4.52442e-13 PD=3.1e-06 PS=2.35726e-06 $X=4890 $Y=2745 $dt=6
M26 vdd3i! RN 23 vdd3i! pe3i L=3e-07 W=1.02e-06 AD=9.30148e-13 AS=4.896e-13 PD=3.58417e-06 PS=3e-06 $X=6430 $Y=2800 $dt=6
M27 29 22 vdd3i! vdd3i! pe3i L=3e-07 W=4.2e-07 AD=5.25e-14 AS=3.83002e-13 PD=6.7e-07 PS=1.47583e-06 $X=7890 $Y=3060 $dt=6
M28 23 15 29 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=1.218e-13 AS=5.25e-14 PD=9.22677e-07 PS=6.7e-07 $X=8440 $Y=3060 $dt=6
M29 26 16 23 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=4.08e-13 AS=2.465e-13 PD=2.66e-06 PS=1.86732e-06 $X=9285 $Y=2670 $dt=6
M30 15 C vdd3i! vdd3i! pe3i L=3e-07 W=7.2e-07 AD=3.0675e-13 AS=6.327e-13 PD=2.37071e-06 PS=3.56e-06 $X=10970 $Y=2735 $dt=6
M31 vdd3i! 15 16 vdd3i! pe3i L=3e-07 W=7.2e-07 AD=3.27981e-13 AS=4.01587e-13 PD=1.59258e-06 PS=3.03778e-06 $X=12390 $Y=2800 $dt=6
M32 31 22 vdd3i! vdd3i! pe3i L=3e-07 W=7.9e-07 AD=1.16525e-13 AS=3.59869e-13 PD=1.085e-06 PS=1.74742e-06 $X=13570 $Y=2730 $dt=6
M33 24 15 31 vdd3i! pe3i L=3e-07 W=7.9e-07 AD=2.25379e-13 AS=1.16525e-13 PD=1.73669e-06 PS=1.085e-06 $X=14165 $Y=2730 $dt=6
M34 30 16 24 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=5.25e-14 AS=1.19821e-13 PD=6.7e-07 PS=9.23306e-07 $X=15005 $Y=3100 $dt=6
M35 vdd3i! 25 30 vdd3i! pe3i L=3e-07 W=4.2e-07 AD=6.29844e-13 AS=5.25e-14 PD=2.86017e-06 PS=6.7e-07 $X=15555 $Y=3100 $dt=6
M36 vdd3i! RN 24 vdd3i! pe3i L=3e-07 W=7.9e-07 AD=1.18471e-12 AS=3.19387e-13 PD=5.37983e-06 PS=2.5195e-06 $X=16775 $Y=2410 $dt=6
M37 vdd3i! 24 25 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.807e-13 AS=6.768e-13 PD=1.95e-06 PS=3.78e-06 $X=18400 $Y=2410 $dt=6
M38 Q 24 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=3.807e-13 PD=3.78e-06 PS=1.95e-06 $X=19240 $Y=2410 $dt=6
.ends SDFRRQJI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO2JI3VX0                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO2JI3VX0 vdd3i! gnd3i! B Q A
*.DEVICECLIMB
** N=7 EP=5 FDC=4
M0 Q B gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=7.244e-13 PD=9.6e-07 PS=4.14e-06 $X=500 $Y=1130 $dt=5
M1 gnd3i! A Q gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=7.244e-13 AS=1.134e-13 PD=4.14e-06 PS=9.6e-07 $X=1390 $Y=1130 $dt=5
M2 7 B vdd3i! vdd3i! pe3i L=3e-07 W=8.5e-07 AD=1.0625e-13 AS=9.298e-13 PD=1.1e-06 PS=4.68e-06 $X=720 $Y=2410 $dt=6
M3 Q A 7 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=4.08e-13 AS=1.0625e-13 PD=2.66e-06 PS=1.1e-06 $X=1270 $Y=2410 $dt=6
.ends NO2JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA4JI3VX0                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA4JI3VX0 vdd3i! gnd3i! D Q C B A
*.DEVICECLIMB
** N=11 EP=7 FDC=8
M0 9 D gnd3i! gnd3i! ne3i L=3.5e-07 W=8e-07 AD=1.2e-13 AS=7.868e-13 PD=1.1e-06 PS=3.82e-06 $X=810 $Y=750 $dt=5
M1 10 C 9 gnd3i! ne3i L=3.5e-07 W=8e-07 AD=1.2e-13 AS=1.2e-13 PD=1.1e-06 PS=1.1e-06 $X=1460 $Y=750 $dt=5
M2 11 B 10 gnd3i! ne3i L=3.5e-07 W=8e-07 AD=1.2e-13 AS=1.2e-13 PD=1.1e-06 PS=1.1e-06 $X=2110 $Y=750 $dt=5
M3 Q A 11 gnd3i! ne3i L=3.5e-07 W=8e-07 AD=3.84e-13 AS=1.2e-13 PD=2.56e-06 PS=1.1e-06 $X=2760 $Y=750 $dt=5
M4 Q D vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=1.89e-13 AS=9.882e-13 PD=1.24e-06 PS=3.92e-06 $X=540 $Y=2410 $dt=6
M5 vdd3i! C Q vdd3i! pe3i L=3e-07 W=7e-07 AD=9.882e-13 AS=1.89e-13 PD=3.92e-06 PS=1.24e-06 $X=1380 $Y=2410 $dt=6
M6 Q B vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=1.89e-13 AS=9.882e-13 PD=1.24e-06 PS=3.92e-06 $X=2240 $Y=2410 $dt=6
M7 vdd3i! A Q vdd3i! pe3i L=3e-07 W=7e-07 AD=9.882e-13 AS=1.89e-13 PD=3.92e-06 PS=1.24e-06 $X=3080 $Y=2410 $dt=6
.ends NA4JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA2JI3VX0                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA2JI3VX0 vdd3i! gnd3i! B Q A
*.DEVICECLIMB
** N=7 EP=5 FDC=4
M0 7 B gnd3i! gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=7e-14 AS=5.892e-13 PD=8.1e-07 PS=3.54e-06 $X=670 $Y=990 $dt=5
M1 Q A 7 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=2.688e-13 AS=7e-14 PD=2.08e-06 PS=8.1e-07 $X=1270 $Y=990 $dt=5
M2 Q B vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=1.89e-13 AS=1.1114e-12 PD=1.24e-06 PS=4.94e-06 $X=550 $Y=2410 $dt=6
M3 vdd3i! A Q vdd3i! pe3i L=3e-07 W=7e-07 AD=1.1114e-12 AS=1.89e-13 PD=4.94e-06 PS=1.24e-06 $X=1390 $Y=2410 $dt=6
.ends NA2JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ON21JI3VX4                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ON21JI3VX4 vdd3i! gnd3i! B A C Q
*.DEVICECLIMB
** N=11 EP=6 FDC=16
M0 gnd3i! B 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=4.272e-13 PD=1.43e-06 PS=2.74e-06 $X=620 $Y=660 $dt=5
M1 10 A gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=2.403e-13 PD=1.43e-06 PS=1.43e-06 $X=1510 $Y=660 $dt=5
M2 8 C 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.868e-13 AS=2.403e-13 PD=2.70971e-06 PS=1.43e-06 $X=2400 $Y=660 $dt=5
M3 gnd3i! 8 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.35783e-13 AS=4.34e-13 PD=1.42065e-06 PS=2.92971e-06 $X=3930 $Y=660 $dt=5
M4 Q 9 gnd3i! gnd3i! ne3i L=3.49164e-07 W=8.96213e-07 AD=2.32912e-13 AS=2.37429e-13 PD=1.42121e-06 PS=1.43057e-06 $X=4820 $Y=660 $dt=5
M5 gnd3i! 9 Q gnd3i! ne3i L=3.49164e-07 W=8.96213e-07 AD=2.32912e-13 AS=2.32912e-13 PD=1.42121e-06 PS=1.42121e-06 $X=5680 $Y=660 $dt=5
M6 Q 9 gnd3i! gnd3i! ne3i L=3.49164e-07 W=8.96213e-07 AD=2.32912e-13 AS=2.32912e-13 PD=1.42121e-06 PS=1.42121e-06 $X=6570 $Y=660 $dt=5
M7 gnd3i! 9 Q gnd3i! ne3i L=3.49164e-07 W=8.96213e-07 AD=4.19812e-13 AS=2.32912e-13 PD=2.73121e-06 PS=1.42121e-06 $X=7430 $Y=660 $dt=5
M8 11 B vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=9.418e-13 PD=1.66e-06 PS=4.63e-06 $X=695 $Y=2410 $dt=6
M9 8 A 11 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.68825e-13 AS=1.7625e-13 PD=2.075e-06 PS=1.66e-06 $X=1245 $Y=2410 $dt=6
M10 vdd3i! C 8 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.285e-12 AS=4.68825e-13 PD=5.02e-06 PS=2.075e-06 $X=2210 $Y=2410 $dt=6
M11 vdd3i! 8 9 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=5.48179e-13 AS=6.768e-13 PD=2.4141e-06 PS=3.78e-06 $X=4020 $Y=2410 $dt=6
M12 Q 9 vdd3i! vdd3i! pe3i L=3.00021e-07 W=1.42657e-06 AD=3.433e-13 AS=5.54621e-13 PD=1.92657e-06 PS=2.44247e-06 $X=4960 $Y=2410 $dt=6
M13 vdd3i! 9 Q vdd3i! pe3i L=3.00021e-07 W=1.42657e-06 AD=4.866e-13 AS=3.433e-13 PD=2.35657e-06 PS=1.92657e-06 $X=5800 $Y=2410 $dt=6
M14 Q 9 vdd3i! vdd3i! pe3i L=3.00021e-07 W=1.42657e-06 AD=3.433e-13 AS=4.866e-13 PD=1.92657e-06 PS=2.35657e-06 $X=6640 $Y=2410 $dt=6
M15 vdd3i! 9 Q vdd3i! pe3i L=3.00021e-07 W=1.42657e-06 AD=8.562e-13 AS=3.433e-13 PD=4.53657e-06 PS=1.92657e-06 $X=7480 $Y=2410 $dt=6
.ends ON21JI3VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AND2JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AND2JI3VX1 vdd3i! gnd3i! A B Q
*.DEVICECLIMB
** N=8 EP=5 FDC=6
M0 8 A 7 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=7e-14 AS=2.688e-13 PD=8.1e-07 PS=2.08e-06 $X=820 $Y=990 $dt=5
M1 gnd3i! B 8 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=2.57137e-13 AS=7e-14 PD=1.43669e-06 PS=8.1e-07 $X=1420 $Y=990 $dt=5
M2 Q 7 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=4.08663e-13 PD=2.74e-06 PS=2.28331e-06 $X=2390 $Y=660 $dt=5
M3 7 A vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=1.89e-13 AS=7.276e-13 PD=1.24e-06 PS=4.56e-06 $X=580 $Y=2410 $dt=6
M4 vdd3i! B 7 vdd3i! pe3i L=3e-07 W=7e-07 AD=3.64829e-13 AS=1.89e-13 PD=1.6455e-06 PS=1.24e-06 $X=1420 $Y=2410 $dt=6
M5 Q 7 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=7.34871e-13 PD=3.78e-06 PS=3.3145e-06 $X=2440 $Y=2410 $dt=6
.ends AND2JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA4JI3VX2                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA4JI3VX2 vdd3i! gnd3i! Q D C B A
*.DEVICECLIMB
** N=14 EP=7 FDC=16
M0 9 D gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.78e-13 AS=6.098e-13 PD=1.29e-06 PS=3.52e-06 $X=660 $Y=660 $dt=5
M1 13 C 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.8245e-13 AS=1.78e-13 PD=1.3e-06 PS=1.29e-06 $X=1410 $Y=660 $dt=5
M2 10 B 13 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.78e-13 AS=1.8245e-13 PD=1.29e-06 PS=1.3e-06 $X=2170 $Y=660 $dt=5
M3 Q A 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.293e-13 AS=1.78e-13 PD=1.63e-06 PS=1.29e-06 $X=2920 $Y=660 $dt=5
M4 11 A Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.78e-13 AS=3.293e-13 PD=1.29e-06 PS=1.63e-06 $X=4010 $Y=660 $dt=5
M5 14 B 11 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.8245e-13 AS=1.78e-13 PD=1.3e-06 PS=1.29e-06 $X=4760 $Y=660 $dt=5
M6 12 C 14 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.78e-13 AS=1.8245e-13 PD=1.29e-06 PS=1.3e-06 $X=5520 $Y=660 $dt=5
M7 gnd3i! D 12 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=6.098e-13 AS=1.78e-13 PD=3.52e-06 PS=1.29e-06 $X=6270 $Y=660 $dt=5
M8 vdd3i! D Q vdd3i! pe3i L=3.00056e-07 W=9.91066e-07 AD=6.12287e-13 AS=4.22737e-13 PD=2.90357e-06 PS=2.83607e-06 $X=620 $Y=2410 $dt=6
M9 vdd3i! C Q vdd3i! pe3i L=3.00056e-07 W=9.91066e-07 AD=6.12287e-13 AS=2.21137e-13 PD=2.90357e-06 PS=1.45607e-06 $X=1440 $Y=2410 $dt=6
M10 Q B vdd3i! vdd3i! pe3i L=3.00056e-07 W=9.91066e-07 AD=2.21137e-13 AS=6.12287e-13 PD=1.45607e-06 PS=2.90357e-06 $X=2280 $Y=2410 $dt=6
M11 vdd3i! A Q vdd3i! pe3i L=3.00056e-07 W=9.91066e-07 AD=6.12287e-13 AS=2.93137e-13 PD=2.90357e-06 PS=1.60607e-06 $X=2995 $Y=2410 $dt=6
M12 Q A vdd3i! vdd3i! pe3i L=3.00056e-07 W=9.91066e-07 AD=2.93137e-13 AS=6.12287e-13 PD=1.60607e-06 PS=2.90357e-06 $X=3985 $Y=2410 $dt=6
M13 vdd3i! B Q vdd3i! pe3i L=3.00056e-07 W=9.91066e-07 AD=6.12287e-13 AS=2.21137e-13 PD=2.90357e-06 PS=1.45607e-06 $X=4700 $Y=2410 $dt=6
M14 Q C vdd3i! vdd3i! pe3i L=3.00056e-07 W=9.91066e-07 AD=2.21137e-13 AS=6.12287e-13 PD=1.45607e-06 PS=2.90357e-06 $X=5540 $Y=2410 $dt=6
M15 Q D vdd3i! vdd3i! pe3i L=3.00056e-07 W=9.91066e-07 AD=4.22737e-13 AS=6.12287e-13 PD=2.83607e-06 PS=2.90357e-06 $X=6360 $Y=2410 $dt=6
.ends NA4JI3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO2I1JI3VX2                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO2I1JI3VX2 vdd3i! gnd3i! AN Q B
*.DEVICECLIMB
** N=9 EP=5 FDC=10
M0 gnd3i! AN 7 gnd3i! ne3i L=3.4889e-07 W=9.00355e-07 AD=2.3695e-13 AS=4.15012e-13 PD=1.44536e-06 PS=2.72536e-06 $X=595 $Y=660 $dt=5
M1 Q 7 gnd3i! gnd3i! ne3i L=3.4889e-07 W=9.00355e-07 AD=2.28113e-13 AS=2.3695e-13 PD=1.41536e-06 PS=1.44536e-06 $X=1500 $Y=660 $dt=5
M2 gnd3i! B Q gnd3i! ne3i L=3.4889e-07 W=9.00355e-07 AD=2.30162e-13 AS=2.28113e-13 PD=1.43036e-06 PS=1.41536e-06 $X=2340 $Y=660 $dt=5
M3 Q B gnd3i! gnd3i! ne3i L=3.4889e-07 W=9.00355e-07 AD=2.28113e-13 AS=2.30162e-13 PD=1.41536e-06 PS=1.43036e-06 $X=3230 $Y=660 $dt=5
M4 gnd3i! 7 Q gnd3i! ne3i L=3.4889e-07 W=9.00355e-07 AD=4.20212e-13 AS=2.28113e-13 PD=2.75536e-06 PS=1.41536e-06 $X=4070 $Y=660 $dt=5
M5 vdd3i! AN 7 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.998e-13 AS=6.768e-13 PD=2.595e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=6
M6 8 7 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.115e-13 AS=6.998e-13 PD=1.71e-06 PS=2.595e-06 $X=1755 $Y=2410 $dt=6
M7 Q B 8 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.8775e-13 AS=2.115e-13 PD=1.96e-06 PS=1.71e-06 $X=2355 $Y=2410 $dt=6
M8 9 B Q vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.115e-13 AS=3.8775e-13 PD=1.71e-06 PS=1.96e-06 $X=3205 $Y=2410 $dt=6
M9 vdd3i! 7 9 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.3642e-12 AS=2.115e-13 PD=5.11e-06 PS=1.71e-06 $X=3805 $Y=2410 $dt=6
.ends NO2I1JI3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: EO2JI3VX0                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt EO2JI3VX0 vdd3i! gnd3i! B A Q
*.DEVICECLIMB
** N=10 EP=5 FDC=10
M0 7 B gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.628e-13 PD=9.6e-07 PS=3.52e-06 $X=660 $Y=1130 $dt=5
M1 gnd3i! A 7 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.0445e-13 AS=1.134e-13 PD=1.34e-06 PS=9.6e-07 $X=1550 $Y=1130 $dt=5
M2 8 B gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=2.0445e-13 PD=6.7e-07 PS=1.34e-06 $X=2670 $Y=980 $dt=5
M3 Q A 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.503e-13 AS=5.25e-14 PD=1.15e-06 PS=6.7e-07 $X=3270 $Y=980 $dt=5
M4 gnd3i! 7 Q gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.0464e-12 AS=1.503e-13 PD=4.3e-06 PS=1.15e-06 $X=4200 $Y=1130 $dt=5
M5 10 B vdd3i! vdd3i! pe3i L=3e-07 W=9e-07 AD=1.35e-13 AS=7.175e-13 PD=1.2e-06 PS=4.61e-06 $X=575 $Y=2410 $dt=6
M6 7 A 10 vdd3i! pe3i L=3e-07 W=9e-07 AD=5.38188e-13 AS=1.35e-13 PD=3.13778e-06 PS=1.2e-06 $X=1175 $Y=2410 $dt=6
M7 vdd3i! B 9 vdd3i! pe3i L=3e-07 W=1.3e-06 AD=5.321e-13 AS=5.76588e-13 PD=2.43e-06 PS=3.57778e-06 $X=2795 $Y=2520 $dt=6
M8 9 A vdd3i! vdd3i! pe3i L=3e-07 W=1.3e-06 AD=3.835e-13 AS=5.321e-13 PD=1.89e-06 PS=2.43e-06 $X=3765 $Y=2410 $dt=6
M9 Q 7 9 vdd3i! pe3i L=3e-07 W=1.3e-06 AD=6.565e-13 AS=3.835e-13 PD=3.61e-06 PS=1.89e-06 $X=4655 $Y=2410 $dt=6
.ends EO2JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AND2JI3VX0                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AND2JI3VX0 vdd3i! gnd3i! A B Q
*.DEVICECLIMB
** N=8 EP=5 FDC=6
M0 8 A 7 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=7e-14 AS=2.688e-13 PD=8.1e-07 PS=2.08e-06 $X=820 $Y=990 $dt=5
M1 gnd3i! B 8 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=3.536e-13 AS=7e-14 PD=2.12571e-06 PS=8.1e-07 $X=1420 $Y=990 $dt=5
M2 Q 7 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=2.652e-13 PD=1.8e-06 PS=1.59429e-06 $X=2390 $Y=1130 $dt=5
M3 7 A vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=1.89e-13 AS=7.276e-13 PD=1.24e-06 PS=4.56e-06 $X=580 $Y=2410 $dt=6
M4 vdd3i! B 7 vdd3i! pe3i L=3e-07 W=7e-07 AD=5.276e-13 AS=1.89e-13 PD=2.48e-06 PS=1.24e-06 $X=1420 $Y=2410 $dt=6
M5 Q 7 vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=3.36e-13 AS=5.276e-13 PD=2.36e-06 PS=2.48e-06 $X=2440 $Y=2410 $dt=6
.ends AND2JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AN22JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AN22JI3VX1 vdd3i! gnd3i! B A Q C D
*.DEVICECLIMB
** N=11 EP=7 FDC=8
M0 9 B gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=6.098e-13 PD=1.14e-06 PS=3.52e-06 $X=660 $Y=660 $dt=5
M1 Q A 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=1.1125e-13 PD=1.43e-06 PS=1.14e-06 $X=1260 $Y=660 $dt=5
M2 10 C Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=2.403e-13 PD=1.14e-06 PS=1.43e-06 $X=2150 $Y=660 $dt=5
M3 gnd3i! D 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=8.082e-13 AS=1.1125e-13 PD=3.84e-06 PS=1.14e-06 $X=2750 $Y=660 $dt=5
M4 vdd3i! B 11 vdd3i! pe3i L=3.01094e-07 W=1.47213e-06 AD=4.29e-13 AS=6.0945e-13 PD=2.32213e-06 PS=3.77213e-06 $X=660 $Y=2410 $dt=6
M5 11 A vdd3i! vdd3i! pe3i L=3.01094e-07 W=1.47213e-06 AD=4.05825e-13 AS=4.29e-13 PD=2.06213e-06 PS=2.32213e-06 $X=1310 $Y=2410 $dt=6
M6 Q C 11 vdd3i! pe3i L=3.01094e-07 W=1.47213e-06 AD=2.9925e-13 AS=4.05825e-13 PD=1.92213e-06 PS=2.06213e-06 $X=2200 $Y=2410 $dt=6
M7 11 D Q vdd3i! pe3i L=3.01094e-07 W=1.47213e-06 AD=6.252e-13 AS=2.9925e-13 PD=3.77213e-06 PS=1.92213e-06 $X=3100 $Y=2410 $dt=6
.ends AN22JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO2JI3VX2                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO2JI3VX2 vdd3i! gnd3i! B A Q
*.DEVICECLIMB
** N=8 EP=5 FDC=8
M0 Q B gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=6.842e-13 PD=1.43e-06 PS=3.64e-06 $X=720 $Y=660 $dt=5
M1 gnd3i! A Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.494e-13 AS=2.403e-13 PD=1.86e-06 PS=1.43e-06 $X=1610 $Y=660 $dt=5
M2 Q A gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=3.494e-13 PD=1.43e-06 PS=1.86e-06 $X=2580 $Y=660 $dt=5
M3 gnd3i! B Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=6.098e-13 AS=2.403e-13 PD=3.52e-06 PS=1.43e-06 $X=3470 $Y=660 $dt=5
M4 7 B vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=1.6898e-12 PD=1.66e-06 PS=5.48e-06 $X=1120 $Y=2410 $dt=6
M5 Q A 7 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.807e-13 AS=1.7625e-13 PD=1.95e-06 PS=1.66e-06 $X=1670 $Y=2410 $dt=6
M6 8 A Q vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.7625e-13 AS=3.807e-13 PD=1.66e-06 PS=1.95e-06 $X=2510 $Y=2410 $dt=6
M7 vdd3i! B 8 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=1.6898e-12 AS=1.7625e-13 PD=5.48e-06 PS=1.66e-06 $X=3060 $Y=2410 $dt=6
.ends NO2JI3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AO21JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AO21JI3VX1 vdd3i! gnd3i! B A C Q
*.DEVICECLIMB
** N=10 EP=6 FDC=8
M0 8 B gnd3i! gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=7e-14 AS=5.768e-13 PD=8.1e-07 PS=3.52e-06 $X=660 $Y=990 $dt=5
M1 9 A 8 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=1.708e-13 AS=7e-14 PD=1.17e-06 PS=8.1e-07 $X=1260 $Y=990 $dt=5
M2 gnd3i! C 9 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=3.94626e-13 AS=1.708e-13 PD=1.68386e-06 PS=1.17e-06 $X=2220 $Y=990 $dt=5
M3 Q 9 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=6.27174e-13 PD=2.74e-06 PS=2.67614e-06 $X=3510 $Y=660 $dt=5
M4 vdd3i! B 10 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=3.8185e-13 AS=4.08e-13 PD=2.53e-06 PS=2.66e-06 $X=620 $Y=2410 $dt=6
M5 10 A vdd3i! vdd3i! pe3i L=3e-07 W=8.5e-07 AD=2.295e-13 AS=3.8185e-13 PD=1.39e-06 PS=2.53e-06 $X=1340 $Y=2410 $dt=6
M6 9 C 10 vdd3i! pe3i L=3e-07 W=8.5e-07 AD=4.08e-13 AS=2.295e-13 PD=2.66e-06 PS=1.39e-06 $X=2180 $Y=2410 $dt=6
M7 Q 9 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=7.0775e-13 PD=3.78e-06 PS=4.73e-06 $X=3560 $Y=2410 $dt=6
.ends AO21JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA2I1JI3VX2                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA2I1JI3VX2 vdd3i! gnd3i! AN Q B
*.DEVICECLIMB
** N=9 EP=5 FDC=10
M0 gnd3i! AN 7 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.672e-13 AS=4.272e-13 PD=2.05e-06 PS=2.74e-06 $X=620 $Y=660 $dt=5
M1 8 7 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=4.672e-13 PD=1.14e-06 PS=2.05e-06 $X=1780 $Y=660 $dt=5
M2 Q B 8 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.759e-13 AS=1.1125e-13 PD=1.51e-06 PS=1.14e-06 $X=2380 $Y=660 $dt=5
M3 9 B Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=2.759e-13 PD=1.14e-06 PS=1.51e-06 $X=3350 $Y=660 $dt=5
M4 gnd3i! 7 9 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=7.09e-13 AS=1.1125e-13 PD=3.68e-06 PS=1.14e-06 $X=3950 $Y=660 $dt=5
M5 vdd3i! AN 7 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=9.9878e-13 AS=6.768e-13 PD=4.57664e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=6
M6 Q 7 vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=2.7e-13 AS=7.08355e-13 PD=1.54e-06 PS=3.24584e-06 $X=1540 $Y=2410 $dt=6
M7 vdd3i! B Q vdd3i! pe3i L=3e-07 W=1e-06 AD=7.08355e-13 AS=2.7e-13 PD=3.24584e-06 PS=1.54e-06 $X=2380 $Y=2410 $dt=6
M8 Q B vdd3i! vdd3i! pe3i L=3e-07 W=1e-06 AD=2.7e-13 AS=7.08355e-13 PD=1.54e-06 PS=3.24584e-06 $X=3280 $Y=2410 $dt=6
M9 vdd3i! 7 Q vdd3i! pe3i L=3e-07 W=1e-06 AD=7.08355e-13 AS=2.7e-13 PD=3.24584e-06 PS=1.54e-06 $X=4120 $Y=2410 $dt=6
.ends NA2I1JI3VX2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NA22JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NA22JI3VX1 vdd3i! gnd3i! A B C Q
*.DEVICECLIMB
** N=10 EP=6 FDC=8
M0 9 A 8 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=7e-14 AS=2.688e-13 PD=8.1e-07 PS=2.08e-06 $X=620 $Y=990 $dt=5
M1 gnd3i! B 9 gnd3i! ne3i L=3.5e-07 W=5.6e-07 AD=3.3376e-13 AS=7e-14 PD=1.56028e-06 PS=8.1e-07 $X=1220 $Y=990 $dt=5
M2 10 C gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=5.3044e-13 PD=1.14e-06 PS=2.47972e-06 $X=2350 $Y=660 $dt=5
M3 Q 8 10 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=1.1125e-13 PD=2.74e-06 PS=1.14e-06 $X=2950 $Y=660 $dt=5
M4 8 A vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=1.89e-13 AS=7.66562e-13 PD=1.24e-06 PS=3.33273e-06 $X=510 $Y=2410 $dt=6
M5 vdd3i! B 8 vdd3i! pe3i L=3e-07 W=7e-07 AD=7.66562e-13 AS=1.89e-13 PD=3.33273e-06 PS=1.24e-06 $X=1350 $Y=2410 $dt=6
M6 vdd3i! C Q vdd3i! pe3i L=3.00052e-07 W=9.98995e-07 AD=1.09399e-12 AS=2.255e-13 PD=4.75626e-06 PS=1.46899e-06 $X=2190 $Y=2410 $dt=6
M7 Q 8 vdd3i! vdd3i! pe3i L=3.00052e-07 W=9.98995e-07 AD=2.255e-13 AS=1.09399e-12 PD=1.46899e-06 PS=4.75626e-06 $X=3030 $Y=2410 $dt=6
.ends NA22JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: MU2JI3VX0                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt MU2JI3VX0 vdd3i! gnd3i! S IN0 IN1 Q
*.DEVICECLIMB
** N=13 EP=6 FDC=12
M0 gnd3i! S 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.5315e-13 AS=2.016e-13 PD=1.165e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=5
M1 9 IN0 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.5315e-13 PD=6.7e-07 PS=1.165e-06 $X=1550 $Y=965 $dt=5
M2 11 8 9 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.134e-13 AS=5.25e-14 PD=9.6e-07 PS=6.7e-07 $X=2150 $Y=965 $dt=5
M3 10 S 11 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=5.25e-14 AS=1.134e-13 PD=6.7e-07 PS=9.6e-07 $X=3040 $Y=965 $dt=5
M4 gnd3i! IN1 10 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=3.148e-13 AS=5.25e-14 PD=1.88e-06 PS=6.7e-07 $X=3640 $Y=965 $dt=5
M5 Q 11 gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=3.148e-13 PD=1.8e-06 PS=1.88e-06 $X=4630 $Y=1130 $dt=5
M6 vdd3i! S 8 vdd3i! pe3i L=3e-07 W=5e-07 AD=1.78281e-13 AS=2.525e-13 PD=1.10156e-06 PS=2.01e-06 $X=645 $Y=2675 $dt=6
M7 12 IN0 vdd3i! vdd3i! pe3i L=3e-07 W=7.8e-07 AD=1.17e-13 AS=2.78119e-13 PD=1.08e-06 PS=1.71844e-06 $X=1575 $Y=2675 $dt=6
M8 11 S 12 vdd3i! pe3i L=3e-07 W=7.8e-07 AD=2.301e-13 AS=1.17e-13 PD=1.37e-06 PS=1.08e-06 $X=2175 $Y=2675 $dt=6
M9 13 8 11 vdd3i! pe3i L=3e-07 W=7.8e-07 AD=1.17e-13 AS=2.301e-13 PD=1.08e-06 PS=1.37e-06 $X=3065 $Y=2675 $dt=6
M10 vdd3i! IN1 13 vdd3i! pe3i L=3e-07 W=7.8e-07 AD=5.0563e-13 AS=1.17e-13 PD=2.58243e-06 PS=1.08e-06 $X=3665 $Y=2675 $dt=6
M11 Q 11 vdd3i! vdd3i! pe3i L=3e-07 W=7e-07 AD=3.535e-13 AS=4.5377e-13 PD=2.41e-06 PS=2.31757e-06 $X=4655 $Y=2410 $dt=6
.ends MU2JI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: OR3JI3VX1                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt OR3JI3VX1 vdd3i! gnd3i! A B C Q
*.DEVICECLIMB
** N=10 EP=6 FDC=8
M0 gnd3i! A 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.482e-13 AS=2.016e-13 PD=2.04e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=5
M1 8 B gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.116e-13 AS=2.482e-13 PD=1.78e-06 PS=2.04e-06 $X=1390 $Y=1310 $dt=5
M2 gnd3i! C 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.66689e-13 AS=2.116e-13 PD=1.17398e-06 PS=1.78e-06 $X=2160 $Y=1130 $dt=5
M3 Q 8 gnd3i! gnd3i! ne3i L=3.50112e-07 W=8.98284e-07 AD=4.174e-13 AS=3.56511e-13 PD=2.72828e-06 PS=2.51087e-06 $X=2970 $Y=660 $dt=5
M4 9 A 8 vdd3i! pe3i L=3e-07 W=1e-06 AD=1.375e-13 AS=4.8e-13 PD=1.275e-06 PS=2.96e-06 $X=670 $Y=2720 $dt=6
M5 10 B 9 vdd3i! pe3i L=3e-07 W=1e-06 AD=1.375e-13 AS=1.375e-13 PD=1.275e-06 PS=1.275e-06 $X=1245 $Y=2720 $dt=6
M6 vdd3i! C 10 vdd3i! pe3i L=3e-07 W=1e-06 AD=5.59502e-13 AS=1.375e-13 PD=2.19087e-06 PS=1.275e-06 $X=1820 $Y=2720 $dt=6
M7 Q 8 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=7.88898e-13 PD=3.78e-06 PS=3.08913e-06 $X=3000 $Y=2410 $dt=6
.ends OR3JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ON211JI3VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ON211JI3VX1 vdd3i! gnd3i! B Q A C D
*.DEVICECLIMB
** N=11 EP=7 FDC=8
M0 Q B 9 gnd3i! ne3i L=3.4889e-07 W=9.00355e-07 AD=2.27987e-13 AS=4.20337e-13 PD=1.41536e-06 PS=2.75536e-06 $X=620 $Y=660 $dt=5
M1 9 A Q gnd3i! ne3i L=3.4889e-07 W=9.00355e-07 AD=2.30287e-13 AS=2.27987e-13 PD=1.43036e-06 PS=1.41536e-06 $X=1460 $Y=660 $dt=5
M2 10 C 9 gnd3i! ne3i L=3.4889e-07 W=9.00355e-07 AD=1.21188e-13 AS=2.30287e-13 PD=1.17536e-06 PS=1.43036e-06 $X=2350 $Y=660 $dt=5
M3 gnd3i! D 10 gnd3i! ne3i L=3.4889e-07 W=9.00355e-07 AD=4.20337e-13 AS=1.21188e-13 PD=2.75536e-06 PS=1.17536e-06 $X=2950 $Y=660 $dt=5
M4 11 B vdd3i! vdd3i! pe3i L=3e-07 W=1.38e-06 AD=1.725e-13 AS=9.388e-13 PD=1.63e-06 PS=4.63e-06 $X=695 $Y=2410 $dt=6
M5 Q A 11 vdd3i! pe3i L=3e-07 W=1.38e-06 AD=4.69617e-13 AS=1.725e-13 PD=2.38255e-06 PS=1.63e-06 $X=1245 $Y=2410 $dt=6
M6 vdd3i! C Q vdd3i! pe3i L=3.00049e-07 W=9.66924e-07 AD=4.25413e-13 AS=3.29046e-13 PD=2.34192e-06 PS=1.66938e-06 $X=2210 $Y=2410 $dt=6
M7 Q D vdd3i! vdd3i! pe3i L=3.00049e-07 W=9.66924e-07 AD=4.20162e-13 AS=4.25413e-13 PD=2.80192e-06 PS=2.34192e-06 $X=3000 $Y=2410 $dt=6
.ends ON211JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: AN21JI3VX1                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt AN21JI3VX1 vdd3i! gnd3i! B A Q C
*.DEVICECLIMB
** N=9 EP=6 FDC=6
M0 8 B gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=1.1125e-13 AS=6.47e-13 PD=1.14e-06 PS=3.58e-06 $X=690 $Y=660 $dt=5
M1 Q A 8 gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.28413e-13 AS=1.1125e-13 PD=1.78572e-06 PS=1.14e-06 $X=1290 $Y=660 $dt=5
M2 gnd3i! C Q gnd3i! ne3i L=3.5e-07 W=6.65e-07 AD=6.369e-13 AS=2.45387e-13 PD=3.6e-06 PS=1.33428e-06 $X=2310 $Y=885 $dt=5
M3 vdd3i! B 9 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=4.371e-13 AS=6.768e-13 PD=2.03e-06 PS=3.78e-06 $X=620 $Y=2410 $dt=6
M4 9 A vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=3.807e-13 AS=4.371e-13 PD=1.95e-06 PS=2.03e-06 $X=1540 $Y=2410 $dt=6
M5 Q C 9 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=7.614e-13 AS=3.807e-13 PD=3.9e-06 PS=1.95e-06 $X=2380 $Y=2410 $dt=6
.ends AN21JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: INJI3VX0                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt INJI3VX0 vdd3i! gnd3i! A Q
*.DEVICECLIMB
** N=5 EP=4 FDC=2
M0 Q A gnd3i! gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=2.016e-13 AS=6.248e-13 PD=1.8e-06 PS=3.62e-06 $X=710 $Y=1130 $dt=5
M1 Q A vdd3i! vdd3i! pe3i L=3e-07 W=9.4e-07 AD=4.512e-13 AS=1.0092e-12 PD=2.84e-06 PS=4.76e-06 $X=760 $Y=2410 $dt=6
.ends INJI3VX0

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: NO3I1JI3VX1                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt NO3I1JI3VX1 vdd3i! gnd3i! AN Q B C
*.DEVICECLIMB
** N=10 EP=6 FDC=8
M0 gnd3i! AN 8 gnd3i! ne3i L=3.5e-07 W=4.2e-07 AD=1.99484e-13 AS=2.016e-13 PD=1.19267e-06 PS=1.8e-06 $X=620 $Y=1130 $dt=5
M1 Q 8 gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=2.403e-13 AS=4.22716e-13 PD=1.43e-06 PS=2.52733e-06 $X=1550 $Y=660 $dt=5
M2 gnd3i! B Q gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=3.494e-13 AS=2.403e-13 PD=1.86e-06 PS=1.43e-06 $X=2440 $Y=660 $dt=5
M3 Q C gnd3i! gnd3i! ne3i L=3.5e-07 W=8.9e-07 AD=4.272e-13 AS=3.494e-13 PD=2.74e-06 PS=1.86e-06 $X=3410 $Y=660 $dt=5
M4 vdd3i! AN 8 vdd3i! pe3i L=3e-07 W=7e-07 AD=4.49443e-13 AS=3.36e-13 PD=1.73175e-06 PS=2.36e-06 $X=620 $Y=2415 $dt=6
M5 9 8 vdd3i! vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.1855e-13 AS=9.05307e-13 PD=1.72e-06 PS=3.48825e-06 $X=1770 $Y=2410 $dt=6
M6 10 B 9 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=2.1855e-13 AS=2.1855e-13 PD=1.72e-06 PS=1.72e-06 $X=2380 $Y=2410 $dt=6
M7 Q C 10 vdd3i! pe3i L=3e-07 W=1.41e-06 AD=6.768e-13 AS=2.1855e-13 PD=3.78e-06 PS=1.72e-06 $X=2990 $Y=2410 $dt=6
.ends NO3I1JI3VX1

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DECAP25JI3V                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DECAP25JI3V vdd3i! gnd3i!
*.DEVICECLIMB
** N=5 EP=2 FDC=12
M0 gnd3i! 5 4 gnd3i! ne3i L=3.5e-07 W=8.8e-07 AD=2.376e-13 AS=4.224e-13 PD=1.42e-06 PS=2.72e-06 $X=620 $Y=660 $dt=5
M1 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.94e-06 W=8.8e-07 AD=2.376e-13 AS=2.376e-13 PD=1.42e-06 PS=1.42e-06 $X=1510 $Y=660 $dt=5
M2 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.94e-06 W=8.8e-07 AD=2.376e-13 AS=2.376e-13 PD=1.42e-06 PS=1.42e-06 $X=3990 $Y=660 $dt=5
M3 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.94e-06 W=8.8e-07 AD=2.376e-13 AS=2.376e-13 PD=1.42e-06 PS=1.42e-06 $X=6470 $Y=660 $dt=5
M4 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.94e-06 W=8.8e-07 AD=2.376e-13 AS=2.376e-13 PD=1.42e-06 PS=1.42e-06 $X=8950 $Y=660 $dt=5
M5 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.94e-06 W=8.8e-07 AD=4.312e-13 AS=2.376e-13 PD=2.74e-06 PS=1.42e-06 $X=11430 $Y=660 $dt=5
M6 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.93e-06 W=1.315e-06 AD=3.5505e-13 AS=6.312e-13 PD=1.855e-06 PS=3.59e-06 $X=620 $Y=2505 $dt=6
M7 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.93e-06 W=1.315e-06 AD=3.5505e-13 AS=3.5505e-13 PD=1.855e-06 PS=1.855e-06 $X=3090 $Y=2505 $dt=6
M8 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.93e-06 W=1.315e-06 AD=3.5505e-13 AS=3.5505e-13 PD=1.855e-06 PS=1.855e-06 $X=5560 $Y=2505 $dt=6
M9 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.93e-06 W=1.315e-06 AD=3.5505e-13 AS=3.5505e-13 PD=1.855e-06 PS=1.855e-06 $X=8030 $Y=2505 $dt=6
M10 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.93e-06 W=1.315e-06 AD=3.84638e-13 AS=3.5505e-13 PD=1.9e-06 PS=1.855e-06 $X=10500 $Y=2505 $dt=6
M11 5 4 vdd3i! vdd3i! pe3i L=3e-07 W=1.315e-06 AD=7.56575e-13 AS=3.84638e-13 PD=3.91e-06 PS=1.9e-06 $X=13015 $Y=2505 $dt=6
.ends DECAP25JI3V

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DECAP15JI3V                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DECAP15JI3V vdd3i! gnd3i!
*.DEVICECLIMB
** N=5 EP=2 FDC=8
M0 gnd3i! 5 4 gnd3i! ne3i L=3.5e-07 W=8.8e-07 AD=2.42e-13 AS=4.224e-13 PD=1.43e-06 PS=2.72e-06 $X=620 $Y=660 $dt=5
M1 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.71e-06 W=8.8e-07 AD=2.42e-13 AS=2.42e-13 PD=1.43e-06 PS=1.43e-06 $X=1520 $Y=660 $dt=5
M2 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.71e-06 W=8.8e-07 AD=2.376e-13 AS=2.42e-13 PD=1.42e-06 PS=1.43e-06 $X=3780 $Y=660 $dt=5
M3 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.71e-06 W=8.8e-07 AD=6.046e-13 AS=2.376e-13 PD=3.5e-06 PS=1.42e-06 $X=6030 $Y=660 $dt=5
M4 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.7e-06 W=1.315e-06 AD=3.5505e-13 AS=8.308e-13 PD=1.855e-06 PS=4.37e-06 $X=660 $Y=2505 $dt=6
M5 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.7e-06 W=1.315e-06 AD=3.5505e-13 AS=3.5505e-13 PD=1.855e-06 PS=1.855e-06 $X=2900 $Y=2505 $dt=6
M6 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.7e-06 W=1.315e-06 AD=3.78063e-13 AS=3.5505e-13 PD=1.89e-06 PS=1.855e-06 $X=5140 $Y=2505 $dt=6
M7 5 4 vdd3i! vdd3i! pe3i L=3e-07 W=1.315e-06 AD=7.56575e-13 AS=3.78063e-13 PD=3.91e-06 PS=1.89e-06 $X=7415 $Y=2505 $dt=6
.ends DECAP15JI3V

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DECAP7JI3V                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DECAP7JI3V vdd3i! gnd3i!
*.DEVICECLIMB
** N=5 EP=2 FDC=4
M0 gnd3i! 5 4 gnd3i! ne3i L=3.5e-07 W=8.8e-07 AD=2.376e-13 AS=4.224e-13 PD=1.42e-06 PS=2.72e-06 $X=620 $Y=660 $dt=5
M1 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.75e-06 W=8.8e-07 AD=6.046e-13 AS=2.376e-13 PD=3.5e-06 PS=1.42e-06 $X=1510 $Y=660 $dt=5
M2 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.71e-06 W=1.315e-06 AD=3.87925e-13 AS=8.308e-13 PD=1.905e-06 PS=4.37e-06 $X=660 $Y=2505 $dt=6
M3 5 4 vdd3i! vdd3i! pe3i L=3e-07 W=1.315e-06 AD=7.237e-13 AS=3.87925e-13 PD=3.86e-06 PS=1.905e-06 $X=2960 $Y=2505 $dt=6
.ends DECAP7JI3V

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DECAP5JI3V                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DECAP5JI3V vdd3i! gnd3i!
*.DEVICECLIMB
** N=5 EP=2 FDC=2
M0 gnd3i! 5 4 gnd3i! ne3i L=1.48e-06 W=8.3e-07 AD=5.786e-13 AS=4.568e-13 PD=3.4e-06 PS=2.82e-06 $X=660 $Y=660 $dt=5
M1 5 4 vdd3i! vdd3i! pe3i L=1.46e-06 W=1.36e-06 AD=7.564e-13 AS=8.542e-13 PD=3.9e-06 PS=4.46e-06 $X=660 $Y=2460 $dt=6
.ends DECAP5JI3V

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: DECAP10JI3V                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt DECAP10JI3V vdd3i! gnd3i!
*.DEVICECLIMB
** N=5 EP=2 FDC=6
M0 gnd3i! 5 4 gnd3i! ne3i L=3.5e-07 W=8.8e-07 AD=2.376e-13 AS=4.224e-13 PD=1.42e-06 PS=2.72e-06 $X=620 $Y=660 $dt=5
M1 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.445e-06 W=8.8e-07 AD=2.376e-13 AS=2.376e-13 PD=1.42e-06 PS=1.42e-06 $X=1510 $Y=660 $dt=5
M2 gnd3i! 5 gnd3i! gnd3i! ne3i L=1.445e-06 W=8.8e-07 AD=6.046e-13 AS=2.376e-13 PD=3.5e-06 PS=1.42e-06 $X=3495 $Y=660 $dt=5
M3 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.425e-06 W=1.315e-06 AD=3.5505e-13 AS=8.308e-13 PD=1.855e-06 PS=4.37e-06 $X=660 $Y=2505 $dt=6
M4 vdd3i! 4 vdd3i! vdd3i! pe3i L=1.425e-06 W=1.315e-06 AD=3.71488e-13 AS=3.5505e-13 PD=1.88e-06 PS=1.855e-06 $X=2625 $Y=2505 $dt=6
M5 5 4 vdd3i! vdd3i! pe3i L=3e-07 W=1.315e-06 AD=7.56575e-13 AS=3.71488e-13 PD=3.91e-06 PS=1.88e-06 $X=4615 $Y=2505 $dt=6
.ends DECAP10JI3V

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: aska_dig                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt aska_dig 1 2 enable DAC<0> DAC<1> pulse_active DAC<2> DAC<4> DAC<3> down_switches<4>
+ down_switches<1> down_switches<2> down_switches<3> SPI_CS down_switches<5> SPI_Clk down_switches<6> down_switches<9> down_switches<7> down_switches<8>
+ down_switches<10> down_switches<0> down_switches<11> down_switches<14> down_switches<12> DAC<5> clk down_switches<13> up_switches<0> reset_l
+ down_switches<15> up_switches<9> up_switches<8> up_switches<6> up_switches<3> up_switches<2> porborn down_switches<17> down_switches<16> up_switches<1>
+ up_switches<4> up_switches<10> up_switches<7> SPI_MOSI down_switches<20> down_switches<18> down_switches<19> up_switches<5> up_switches<12> up_switches<11>
+ IC_addr<1> down_switches<21> up_switches<13> down_switches<22> IC_addr<0> up_switches<14> up_switches<15> down_switches<23> down_switches<24> up_switches<22>
+ up_switches<16> down_switches<25> up_switches<17> up_switches<18> up_switches<19> down_switches<26> up_switches<21> down_switches<27> up_switches<20> down_switches<28>
+ up_switches<26> up_switches<23> up_switches<25> up_switches<24> down_switches<31> up_switches<27> up_switches<28> down_switches<30> up_switches<29> down_switches<29>
+ up_switches<30> up_switches<31>
*.DEVICECLIMB
** N=1434 EP=82 FDC=26951
X0 1 2 84 85 86 EN2JI3VX0 $T=40320 185920 1 0 $X=39890 $Y=180800
X1 1 2 87 88 89 EN2JI3VX0 $T=45920 185920 1 0 $X=45490 $Y=180800
X2 1 2 90 91 92 EN2JI3VX0 $T=306880 212800 1 180 $X=300850 $Y=212160
X3 1 2 93 94 95 96 NO3JI3VX1 $T=347760 24640 1 180 $X=343970 $Y=24000
X4 1 2 97 98 99 NA2JI3VX2 $T=307440 105280 0 0 $X=307010 $Y=104640
X5 1 2 100 101 102 103 NO22JI3VX1 $T=328160 168000 0 180 $X=323250 $Y=162880
X6 1 2 104 105 106 107 NO22JI3VX1 $T=397040 141120 1 180 $X=392130 $Y=140480
X7 1 2 108 109 110 111 DFRRQJI3VX2 $T=342720 212800 0 180 $X=326050 $Y=207680
X8 1 2 112 DAC<0> BUJI3VX8 $T=50960 33600 1 0 $X=50530 $Y=28480
X9 1 2 113 DAC<4> BUJI3VX8 $T=67200 33600 1 0 $X=66770 $Y=28480
X10 1 2 114 115 BUJI3VX8 $T=91280 141120 1 0 $X=90850 $Y=136000
X11 1 2 114 116 BUJI3VX8 $T=103600 168000 1 0 $X=103170 $Y=162880
X12 1 2 117 118 BUJI3VX8 $T=126560 203840 0 180 $X=117730 $Y=198720
X13 1 2 117 119 BUJI3VX8 $T=175280 114240 0 0 $X=174850 $Y=113600
X14 1 2 120 DAC<5> BUJI3VX8 $T=176400 24640 1 0 $X=175970 $Y=19520
X15 1 2 117 121 BUJI3VX8 $T=218400 203840 0 0 $X=217970 $Y=203200
X16 1 2 117 122 BUJI3VX8 $T=314720 194880 1 0 $X=314290 $Y=189760
X17 1 2 123 124 121 125 DFRRQJI3VX4 $T=297360 176960 1 180 $X=279010 $Y=176320
X18 1 2 108 126 110 127 DFRRQJI3VX4 $T=334880 203840 1 0 $X=334450 $Y=198720
X19 1 2 128 129 122 130 DFRRQJI3VX4 $T=379120 185920 1 180 $X=360770 $Y=185280
X20 1 2 128 131 122 132 DFRRQJI3VX4 $T=371840 168000 0 0 $X=371410 $Y=167360
X21 1 2 128 133 122 134 DFRRQJI3VX4 $T=407680 168000 1 180 $X=389330 $Y=167360
X22 1 2 128 135 122 136 DFRRQJI3VX4 $T=413840 123200 1 180 $X=395490 $Y=122560
X23 1 2 128 137 122 138 DFRRQJI3VX4 $T=416080 123200 0 180 $X=397730 $Y=118080
X24 1 2 139 140 BUJI3VX1 $T=36960 176960 0 0 $X=36530 $Y=176320
X25 1 2 SPI_Clk 141 BUJI3VX1 $T=120400 96320 0 0 $X=119970 $Y=95680
X26 1 2 clk 142 BUJI3VX1 $T=186480 159040 0 0 $X=186050 $Y=158400
X27 1 2 143 144 BUJI3VX1 $T=207200 87360 1 0 $X=206770 $Y=82240
X28 1 2 145 143 BUJI3VX1 $T=207200 212800 0 0 $X=206770 $Y=212160
X29 1 2 146 147 BUJI3VX1 $T=208320 194880 1 0 $X=207890 $Y=189760
X30 1 2 148 149 BUJI3VX1 $T=211120 194880 1 0 $X=210690 $Y=189760
X31 1 2 141 139 BUJI3VX1 $T=270480 203840 0 180 $X=267250 $Y=198720
X32 1 2 142 150 BUJI3VX1 $T=339360 185920 0 180 $X=336130 $Y=180800
X33 1 2 151 152 BUJI3VX1 $T=403760 105280 0 0 $X=403330 $Y=104640
X34 1 2 153 154 155 156 NO3I2JI3VX1 $T=209440 185920 1 180 $X=205090 $Y=185280
X35 1 2 157 158 159 160 NO3I2JI3VX1 $T=220080 176960 0 0 $X=219650 $Y=176320
X36 1 2 161 162 163 164 165 FAJI3VX1 $T=112000 168000 1 0 $X=111570 $Y=162880
X37 1 2 166 165 167 168 169 FAJI3VX1 $T=129360 159040 1 180 $X=114370 $Y=158400
X38 1 2 170 169 171 172 173 FAJI3VX1 $T=133840 150080 0 180 $X=118850 $Y=144960
X39 1 2 174 175 176 177 162 FAJI3VX1 $T=123200 185920 0 0 $X=122770 $Y=185280
X40 1 2 178 179 180 181 182 FAJI3VX1 $T=137760 212800 0 180 $X=122770 $Y=207680
X41 1 2 183 182 184 185 175 FAJI3VX1 $T=141120 203840 0 180 $X=126130 $Y=198720
X42 1 2 186 187 188 172 189 FAJI3VX1 $T=150640 150080 0 180 $X=135650 $Y=144960
X43 1 2 190 191 192 168 187 FAJI3VX1 $T=150640 150080 1 180 $X=135650 $Y=149440
X44 1 2 193 194 195 164 191 FAJI3VX1 $T=151200 168000 0 180 $X=136210 $Y=162880
X45 1 2 196 197 198 177 194 FAJI3VX1 $T=137760 185920 0 0 $X=137330 $Y=185280
X46 1 2 199 200 201 181 202 FAJI3VX1 $T=140560 212800 0 0 $X=140130 $Y=212160
X47 1 2 203 202 204 185 197 FAJI3VX1 $T=155680 203840 0 180 $X=140690 $Y=198720
X48 1 2 205 206 207 208 209 FAJI3VX1 $T=148400 114240 0 0 $X=147970 $Y=113600
X49 1 2 210 173 211 212 213 FAJI3VX1 $T=164640 141120 1 180 $X=149650 $Y=140480
X50 1 2 214 189 207 212 215 FAJI3VX1 $T=166320 150080 1 180 $X=151330 $Y=149440
X51 1 2 216 209 217 218 219 FAJI3VX1 $T=175840 123200 0 180 $X=160850 $Y=118080
X52 1 2 220 213 221 222 223 FAJI3VX1 $T=180320 141120 0 180 $X=165330 $Y=136000
X53 1 2 224 215 217 222 225 FAJI3VX1 $T=181440 150080 1 180 $X=166450 $Y=149440
X54 1 2 226 227 228 OR2JI3VX0 $T=183680 194880 0 0 $X=183250 $Y=194240
X55 1 2 229 230 231 OR2JI3VX0 $T=208880 168000 0 0 $X=208450 $Y=167360
X56 1 2 232 233 234 OR2JI3VX0 $T=240800 168000 0 0 $X=240370 $Y=167360
X57 1 2 235 230 236 OR2JI3VX0 $T=303520 168000 1 0 $X=303090 $Y=162880
X58 1 2 237 238 239 OR2JI3VX0 $T=388080 159040 1 0 $X=387650 $Y=153920
X59 1 2 240 241 242 243 NA3I1JI3VX1 $T=36960 150080 0 0 $X=36530 $Y=149440
X60 1 2 244 245 246 247 NA3I1JI3VX1 $T=61040 176960 0 0 $X=60610 $Y=176320
X61 1 2 248 249 250 251 NA3I1JI3VX1 $T=64400 168000 1 0 $X=63970 $Y=162880
X62 1 2 252 248 253 254 NA3I1JI3VX1 $T=68880 159040 1 180 $X=64530 $Y=158400
X63 1 2 111 255 256 257 NA3I1JI3VX1 $T=329280 212800 1 180 $X=324930 $Y=212160
X64 1 2 258 259 260 261 NA3I1JI3VX1 $T=337680 168000 0 180 $X=333330 $Y=162880
X65 1 2 132 262 263 134 NA3I1JI3VX1 $T=386960 168000 1 0 $X=386530 $Y=162880
X66 1 2 136 264 138 265 NA3I1JI3VX1 $T=395920 114240 1 180 $X=391570 $Y=113600
X67 1 2 152 266 267 138 NA3I1JI3VX1 $T=401520 114240 1 0 $X=401090 $Y=109120
X68 1 2 114 268 DLY2JI3VX1 $T=77840 212800 0 0 $X=77410 $Y=212160
X69 1 2 269 240 270 271 NA3JI3VX0 $T=40320 168000 0 180 $X=37090 $Y=162880
X70 1 2 272 273 274 275 NA3JI3VX0 $T=57120 159040 1 180 $X=53890 $Y=158400
X71 1 2 276 277 278 279 NA3JI3VX0 $T=58240 150080 0 0 $X=57810 $Y=149440
X72 1 2 269 280 281 282 NA3JI3VX0 $T=67760 185920 0 0 $X=67330 $Y=185280
X73 1 2 282 283 284 285 NA3JI3VX0 $T=75600 194880 0 180 $X=72370 $Y=189760
X74 1 2 286 287 288 289 NA3JI3VX0 $T=133280 123200 1 0 $X=132850 $Y=118080
X75 1 2 290 291 292 293 NA3JI3VX0 $T=141120 114240 0 0 $X=140690 $Y=113600
X76 1 2 294 295 296 297 NA3JI3VX0 $T=154560 105280 0 0 $X=154130 $Y=104640
X77 1 2 298 299 300 154 NA3JI3VX0 $T=194320 176960 0 180 $X=191090 $Y=171840
X78 1 2 301 302 303 304 NA3JI3VX0 $T=194320 185920 1 180 $X=191090 $Y=185280
X79 1 2 305 306 307 308 NA3JI3VX0 $T=196560 203840 1 0 $X=196130 $Y=198720
X80 1 2 309 310 311 312 NA3JI3VX0 $T=240800 185920 1 180 $X=237570 $Y=185280
X81 1 2 313 314 315 316 NA3JI3VX0 $T=250320 159040 0 0 $X=249890 $Y=158400
X82 1 2 154 317 318 319 NA3JI3VX0 $T=271040 185920 1 0 $X=270610 $Y=180800
X83 1 2 242 273 320 321 ON21JI3VX1 $T=36960 159040 0 180 $X=33170 $Y=153920
X84 1 2 269 320 322 323 ON21JI3VX1 $T=38640 159040 1 0 $X=38210 $Y=153920
X85 1 2 324 325 326 327 ON21JI3VX1 $T=62720 168000 1 180 $X=58930 $Y=167360
X86 1 2 281 328 329 280 ON21JI3VX1 $T=72800 185920 0 0 $X=72370 $Y=185280
X87 1 2 330 331 332 333 ON21JI3VX1 $T=180880 176960 0 0 $X=180450 $Y=176320
X88 1 2 334 299 335 336 ON21JI3VX1 $T=191520 168000 1 180 $X=187730 $Y=167360
X89 1 2 337 338 339 303 ON21JI3VX1 $T=194320 185920 1 0 $X=193890 $Y=180800
X90 1 2 231 340 341 342 ON21JI3VX1 $T=202720 168000 1 0 $X=202290 $Y=162880
X91 1 2 230 343 344 345 ON21JI3VX1 $T=209440 176960 0 180 $X=205650 $Y=171840
X92 1 2 346 347 348 349 ON21JI3VX1 $T=210560 185920 0 0 $X=210130 $Y=185280
X93 1 2 350 351 352 353 ON21JI3VX1 $T=218960 203840 1 0 $X=218530 $Y=198720
X94 1 2 311 354 355 310 ON21JI3VX1 $T=237440 185920 1 180 $X=233650 $Y=185280
X95 1 2 356 357 358 234 ON21JI3VX1 $T=241920 159040 0 0 $X=241490 $Y=158400
X96 1 2 359 316 360 361 ON21JI3VX1 $T=249760 168000 0 180 $X=245970 $Y=162880
X97 1 2 362 363 364 365 ON21JI3VX1 $T=250320 168000 0 0 $X=249890 $Y=167360
X98 1 2 237 366 367 368 ON21JI3VX1 $T=258160 33600 0 0 $X=257730 $Y=32960
X99 1 2 230 160 369 345 ON21JI3VX1 $T=264880 176960 0 0 $X=264450 $Y=176320
X100 1 2 370 317 124 371 ON21JI3VX1 $T=285600 185920 0 180 $X=281810 $Y=180800
X101 1 2 237 372 373 374 ON21JI3VX1 $T=283920 33600 0 0 $X=283490 $Y=32960
X102 1 2 237 375 376 377 ON21JI3VX1 $T=285040 24640 0 0 $X=284610 $Y=24000
X103 1 2 378 379 380 381 ON21JI3VX1 $T=317520 168000 1 180 $X=313730 $Y=167360
X104 1 2 237 382 383 384 ON21JI3VX1 $T=337680 33600 0 0 $X=337250 $Y=32960
X105 1 2 237 385 386 387 ON21JI3VX1 $T=348880 42560 1 0 $X=348450 $Y=37440
X106 1 2 388 389 129 390 ON21JI3VX1 $T=360080 185920 1 0 $X=359650 $Y=180800
X107 1 2 237 391 392 393 ON21JI3VX1 $T=371280 33600 1 180 $X=367490 $Y=32960
X108 1 2 237 394 395 396 ON21JI3VX1 $T=376880 24640 0 0 $X=376450 $Y=24000
X109 1 2 262 397 131 398 ON21JI3VX1 $T=384720 168000 0 180 $X=380930 $Y=162880
X110 1 2 134 399 400 401 ON21JI3VX1 $T=390880 159040 1 180 $X=387090 $Y=158400
X111 1 2 402 107 403 404 ON21JI3VX1 $T=391440 141120 1 180 $X=387650 $Y=140480
X112 1 2 405 406 407 136 ON21JI3VX1 $T=388640 114240 0 0 $X=388210 $Y=113600
X113 1 2 263 399 408 239 ON21JI3VX1 $T=392000 159040 1 0 $X=391570 $Y=153920
X114 1 2 264 409 135 407 ON21JI3VX1 $T=397600 114240 0 0 $X=397170 $Y=113600
X115 1 2 138 409 137 266 ON21JI3VX1 $T=403760 114240 0 0 $X=403330 $Y=113600
X116 1 2 410 247 244 325 OA21JI3VX1 $T=69440 176960 1 180 $X=64530 $Y=176320
X117 1 2 91 411 412 413 OA21JI3VX1 $T=316400 212800 0 0 $X=315970 $Y=212160
X118 1 2 114 414 BUJI3VX3 $T=110320 203840 1 0 $X=109890 $Y=198720
X119 1 2 114 415 BUJI3VX3 $T=113680 212800 1 0 $X=113250 $Y=207680
X120 1 2 114 416 BUJI3VX3 $T=119280 212800 1 0 $X=118850 $Y=207680
X121 1 2 114 417 BUJI3VX3 $T=136640 176960 1 0 $X=136210 $Y=171840
X122 1 2 114 418 BUJI3VX3 $T=137200 168000 0 0 $X=136770 $Y=167360
X123 1 2 114 419 BUJI3VX3 $T=137760 185920 1 0 $X=137330 $Y=180800
X124 1 2 114 420 BUJI3VX3 $T=189280 159040 0 0 $X=188850 $Y=158400
X125 1 2 421 up_switches<0> BUJI3VX3 $T=203840 24640 1 0 $X=203410 $Y=19520
X126 1 2 422 up_switches<9> BUJI3VX3 $T=208880 24640 1 0 $X=208450 $Y=19520
X127 1 2 423 up_switches<8> BUJI3VX3 $T=213360 24640 1 0 $X=212930 $Y=19520
X128 1 2 424 up_switches<6> BUJI3VX3 $T=213360 24640 0 0 $X=212930 $Y=24000
X129 1 2 425 up_switches<3> BUJI3VX3 $T=221200 24640 1 180 $X=216850 $Y=24000
X130 1 2 426 up_switches<2> BUJI3VX3 $T=217840 24640 1 0 $X=217410 $Y=19520
X131 1 2 114 427 BUJI3VX3 $T=220640 168000 1 0 $X=220210 $Y=162880
X132 1 2 428 429 BUJI3VX3 $T=220640 194880 1 0 $X=220210 $Y=189760
X133 1 2 114 430 BUJI3VX3 $T=234640 150080 0 180 $X=230290 $Y=144960
X134 1 2 429 146 BUJI3VX3 $T=233520 176960 1 0 $X=233090 $Y=171840
X135 1 2 431 up_switches<1> BUJI3VX3 $T=240800 24640 1 0 $X=240370 $Y=19520
X136 1 2 432 up_switches<4> BUJI3VX3 $T=245840 24640 1 0 $X=245410 $Y=19520
X137 1 2 433 up_switches<10> BUJI3VX3 $T=253120 24640 1 0 $X=252690 $Y=19520
X138 1 2 114 434 BUJI3VX3 $T=255360 123200 0 0 $X=254930 $Y=122560
X139 1 2 435 up_switches<7> BUJI3VX3 $T=258720 24640 1 0 $X=258290 $Y=19520
X140 1 2 436 up_switches<5> BUJI3VX3 $T=264880 24640 1 0 $X=264450 $Y=19520
X141 1 2 437 up_switches<12> BUJI3VX3 $T=271600 24640 1 0 $X=271170 $Y=19520
X142 1 2 438 up_switches<11> BUJI3VX3 $T=277200 24640 1 0 $X=276770 $Y=19520
X143 1 2 439 up_switches<13> BUJI3VX3 $T=282240 24640 1 0 $X=281810 $Y=19520
X144 1 2 440 441 442 443 444 AN211JI3VX1 $T=45360 168000 0 0 $X=44930 $Y=167360
X145 1 2 278 252 272 230 445 AN211JI3VX1 $T=64400 159040 1 180 $X=59490 $Y=158400
X146 1 2 446 447 448 337 449 AN211JI3VX1 $T=193200 176960 0 0 $X=192770 $Y=176320
X147 1 2 348 450 155 451 229 AN211JI3VX1 $T=217280 185920 0 180 $X=212370 $Y=180800
X148 1 2 452 453 381 454 455 AN211JI3VX1 $T=343280 168000 0 180 $X=338370 $Y=162880
X149 1 2 114 456 BUJI3VX16 $T=110320 203840 0 180 $X=93650 $Y=198720
X150 1 2 457 458 BUJI3VX16 $T=159600 203840 1 0 $X=159170 $Y=198720
X151 1 2 114 459 BUJI3VX16 $T=210000 123200 1 0 $X=209570 $Y=118080
X152 1 2 114 460 BUJI3VX16 $T=239680 132160 0 180 $X=223010 $Y=127040
X153 1 2 461 243 BUJI3VX0 $T=44240 150080 0 0 $X=43810 $Y=149440
X154 1 2 462 463 BUJI3VX0 $T=44240 159040 1 0 $X=43810 $Y=153920
X155 1 2 87 464 BUJI3VX0 $T=54880 194880 1 0 $X=54450 $Y=189760
X156 1 2 465 466 BUJI3VX0 $T=62720 185920 1 0 $X=62290 $Y=180800
X157 1 2 467 468 BUJI3VX0 $T=151200 114240 1 0 $X=150770 $Y=109120
X158 1 2 469 470 BUJI3VX0 $T=161840 114240 1 0 $X=161410 $Y=109120
X159 1 2 295 471 BUJI3VX0 $T=162400 96320 1 0 $X=161970 $Y=91200
X160 1 2 472 473 BUJI3VX0 $T=165760 212800 1 0 $X=165330 $Y=207680
X161 1 2 474 475 BUJI3VX0 $T=190400 105280 0 0 $X=189970 $Y=104640
X162 1 2 147 148 BUJI3VX0 $T=204960 194880 0 0 $X=204530 $Y=194240
X163 1 2 149 476 BUJI3VX0 $T=207760 194880 0 0 $X=207330 $Y=194240
X164 1 2 477 478 BUJI3VX0 $T=213920 194880 1 0 $X=213490 $Y=189760
X165 1 2 478 479 BUJI3VX0 $T=215040 203840 1 0 $X=214610 $Y=198720
X166 1 2 480 477 BUJI3VX0 $T=215600 203840 0 0 $X=215170 $Y=203200
X167 1 2 porborn 480 BUJI3VX0 $T=218400 212800 0 0 $X=217970 $Y=212160
X168 1 2 481 428 BUJI3VX0 $T=231840 203840 1 0 $X=231410 $Y=198720
X169 1 2 482 312 BUJI3VX0 $T=238000 176960 1 0 $X=237570 $Y=171840
X170 1 2 483 484 BUJI3VX0 $T=241920 203840 0 0 $X=241490 $Y=203200
X171 1 2 485 486 BUJI3VX0 $T=244720 185920 0 0 $X=244290 $Y=185280
X172 1 2 484 481 BUJI3VX0 $T=244720 212800 1 0 $X=244290 $Y=207680
X173 1 2 SPI_MOSI 487 BUJI3VX0 $T=260400 212800 0 0 $X=259970 $Y=212160
X174 1 2 488 483 BUJI3VX0 $T=264320 212800 1 0 $X=263890 $Y=207680
X175 1 2 489 490 BUJI3VX0 $T=288960 185920 0 0 $X=288530 $Y=185280
X176 1 2 491 492 BUJI3VX0 $T=295680 194880 1 0 $X=295250 $Y=189760
X177 1 2 92 493 BUJI3VX0 $T=302400 203840 0 0 $X=301970 $Y=203200
X178 1 2 494 412 BUJI3VX0 $T=320880 212800 0 0 $X=320450 $Y=212160
X179 1 2 495 496 BUJI3VX0 $T=349440 212800 0 0 $X=349010 $Y=212160
X180 1 2 85 497 84 NA2I1JI3VX1 $T=47600 176960 1 180 $X=43810 $Y=176320
X181 1 2 88 85 87 NA2I1JI3VX1 $T=50960 176960 1 180 $X=47170 $Y=176320
X182 1 2 498 279 323 NA2I1JI3VX1 $T=57680 150080 1 180 $X=53890 $Y=149440
X183 1 2 323 278 498 NA2I1JI3VX1 $T=54320 159040 1 0 $X=53890 $Y=153920
X184 1 2 499 500 466 NA2I1JI3VX1 $T=59360 185920 0 0 $X=58930 $Y=185280
X185 1 2 467 501 192 NA2I1JI3VX1 $T=142240 132160 1 0 $X=141810 $Y=127040
X186 1 2 502 503 501 NA2I1JI3VX1 $T=150080 123200 1 180 $X=146290 $Y=122560
X187 1 2 504 505 506 NA2I1JI3VX1 $T=160720 132160 0 180 $X=156930 $Y=127040
X188 1 2 474 506 188 NA2I1JI3VX1 $T=162960 123200 1 180 $X=159170 $Y=122560
X189 1 2 507 508 330 NA2I1JI3VX1 $T=176960 185920 1 0 $X=176530 $Y=180800
X190 1 2 509 303 510 NA2I1JI3VX1 $T=194880 194880 1 0 $X=194450 $Y=189760
X191 1 2 510 308 511 NA2I1JI3VX1 $T=196000 212800 0 0 $X=195570 $Y=212160
X192 1 2 510 512 509 NA2I1JI3VX1 $T=201600 194880 0 180 $X=197810 $Y=189760
X193 1 2 511 307 510 NA2I1JI3VX1 $T=199360 203840 1 0 $X=198930 $Y=198720
X194 1 2 513 514 515 NA2I1JI3VX1 $T=204960 176960 0 180 $X=201170 $Y=171840
X195 1 2 157 516 517 NA2I1JI3VX1 $T=214480 176960 0 180 $X=210690 $Y=171840
X196 1 2 158 518 159 NA2I1JI3VX1 $T=219520 168000 0 0 $X=219090 $Y=167360
X197 1 2 518 235 157 NA2I1JI3VX1 $T=223440 176960 0 180 $X=219650 $Y=171840
X198 1 2 519 520 486 NA2I1JI3VX1 $T=250320 194880 0 180 $X=246530 $Y=189760
X199 1 2 521 522 523 NA2I1JI3VX1 $T=268240 168000 0 180 $X=264450 $Y=162880
X200 1 2 524 525 526 NA2I1JI3VX1 $T=272720 168000 1 180 $X=268930 $Y=167360
X201 1 2 125 526 527 NA2I1JI3VX1 $T=276640 168000 1 180 $X=272850 $Y=167360
X202 1 2 528 523 529 NA2I1JI3VX1 $T=276640 176960 1 180 $X=272850 $Y=176320
X203 1 2 530 531 532 NA2I1JI3VX1 $T=322560 176960 0 180 $X=318770 $Y=171840
X204 1 2 532 533 530 NA2I1JI3VX1 $T=328160 176960 1 0 $X=327730 $Y=171840
X205 1 2 534 535 536 NA2I1JI3VX1 $T=334320 176960 0 0 $X=333890 $Y=176320
X206 1 2 537 538 DLY1JI3VX1 $T=28560 141120 1 0 $X=28130 $Y=136000
X207 1 2 539 540 DLY1JI3VX1 $T=29680 114240 0 0 $X=29250 $Y=113600
X208 1 2 541 542 DLY1JI3VX1 $T=29680 123200 1 0 $X=29250 $Y=118080
X209 1 2 543 544 DLY1JI3VX1 $T=34160 141120 1 0 $X=33730 $Y=136000
X210 1 2 545 546 DLY1JI3VX1 $T=34160 141120 0 0 $X=33730 $Y=140480
X211 1 2 547 548 DLY1JI3VX1 $T=44240 33600 0 0 $X=43810 $Y=32960
X212 1 2 549 550 DLY1JI3VX1 $T=47040 123200 0 0 $X=46610 $Y=122560
X213 1 2 551 552 DLY1JI3VX1 $T=49840 33600 0 0 $X=49410 $Y=32960
X214 1 2 553 554 DLY1JI3VX1 $T=56000 33600 0 0 $X=55570 $Y=32960
X215 1 2 555 556 DLY1JI3VX1 $T=61600 33600 0 0 $X=61170 $Y=32960
X216 1 2 557 558 DLY1JI3VX1 $T=65520 150080 0 0 $X=65090 $Y=149440
X217 1 2 559 560 DLY1JI3VX1 $T=67200 33600 0 0 $X=66770 $Y=32960
X218 1 2 561 562 DLY1JI3VX1 $T=69440 69440 1 0 $X=69010 $Y=64320
X219 1 2 563 564 DLY1JI3VX1 $T=72240 141120 0 0 $X=71810 $Y=140480
X220 1 2 565 566 DLY1JI3VX1 $T=72800 33600 0 0 $X=72370 $Y=32960
X221 1 2 567 568 DLY1JI3VX1 $T=78400 33600 0 0 $X=77970 $Y=32960
X222 1 2 569 570 DLY1JI3VX1 $T=84560 185920 0 0 $X=84130 $Y=185280
X223 1 2 571 572 DLY1JI3VX1 $T=85120 87360 1 0 $X=84690 $Y=82240
X224 1 2 573 574 DLY1JI3VX1 $T=85120 203840 1 0 $X=84690 $Y=198720
X225 1 2 575 576 DLY1JI3VX1 $T=87360 168000 1 0 $X=86930 $Y=162880
X226 1 2 577 578 DLY1JI3VX1 $T=87360 168000 0 0 $X=86930 $Y=167360
X227 1 2 579 580 DLY1JI3VX1 $T=89040 150080 1 0 $X=88610 $Y=144960
X228 1 2 581 582 DLY1JI3VX1 $T=95200 203840 1 180 $X=89170 $Y=203200
X229 1 2 583 584 DLY1JI3VX1 $T=103040 203840 0 0 $X=102610 $Y=203200
X230 1 2 585 586 DLY1JI3VX1 $T=103600 69440 0 0 $X=103170 $Y=68800
X231 1 2 587 588 DLY1JI3VX1 $T=108640 159040 0 0 $X=108210 $Y=158400
X232 1 2 589 590 DLY1JI3VX1 $T=113680 150080 1 0 $X=113250 $Y=144960
X233 1 2 591 592 DLY1JI3VX1 $T=113680 168000 0 0 $X=113250 $Y=167360
X234 1 2 593 594 DLY1JI3VX1 $T=117040 33600 1 0 $X=116610 $Y=28480
X235 1 2 595 596 DLY1JI3VX1 $T=129360 42560 1 0 $X=128930 $Y=37440
X236 1 2 597 598 DLY1JI3VX1 $T=132160 185920 1 0 $X=131730 $Y=180800
X237 1 2 599 600 DLY1JI3VX1 $T=134960 42560 1 0 $X=134530 $Y=37440
X238 1 2 601 602 DLY1JI3VX1 $T=134960 132160 0 0 $X=134530 $Y=131520
X239 1 2 603 604 DLY1JI3VX1 $T=136080 69440 0 0 $X=135650 $Y=68800
X240 1 2 605 606 DLY1JI3VX1 $T=140560 42560 1 0 $X=140130 $Y=37440
X241 1 2 607 608 DLY1JI3VX1 $T=140560 132160 0 0 $X=140130 $Y=131520
X242 1 2 609 610 DLY1JI3VX1 $T=146160 42560 1 0 $X=145730 $Y=37440
X243 1 2 611 612 DLY1JI3VX1 $T=146160 60480 1 0 $X=145730 $Y=55360
X244 1 2 613 614 DLY1JI3VX1 $T=146160 132160 0 0 $X=145730 $Y=131520
X245 1 2 615 616 DLY1JI3VX1 $T=151760 60480 1 0 $X=151330 $Y=55360
X246 1 2 617 618 DLY1JI3VX1 $T=152880 42560 1 0 $X=152450 $Y=37440
X247 1 2 619 620 DLY1JI3VX1 $T=157360 60480 1 0 $X=156930 $Y=55360
X248 1 2 621 622 DLY1JI3VX1 $T=158480 42560 1 0 $X=158050 $Y=37440
X249 1 2 623 624 DLY1JI3VX1 $T=167440 114240 1 0 $X=167010 $Y=109120
X250 1 2 625 626 DLY1JI3VX1 $T=169120 33600 0 0 $X=168690 $Y=32960
X251 1 2 627 628 DLY1JI3VX1 $T=174720 33600 0 0 $X=174290 $Y=32960
X252 1 2 629 630 DLY1JI3VX1 $T=174720 132160 1 0 $X=174290 $Y=127040
X253 1 2 631 632 DLY1JI3VX1 $T=177520 96320 0 0 $X=177090 $Y=95680
X254 1 2 633 634 DLY1JI3VX1 $T=179200 42560 1 0 $X=178770 $Y=37440
X255 1 2 635 636 DLY1JI3VX1 $T=186480 141120 1 0 $X=186050 $Y=136000
X256 1 2 637 638 DLY1JI3VX1 $T=187600 42560 1 0 $X=187170 $Y=37440
X257 1 2 639 640 DLY1JI3VX1 $T=190960 105280 1 0 $X=190530 $Y=100160
X258 1 2 641 642 DLY1JI3VX1 $T=192080 33600 0 0 $X=191650 $Y=32960
X259 1 2 643 644 DLY1JI3VX1 $T=192080 132160 0 0 $X=191650 $Y=131520
X260 1 2 645 646 DLY1JI3VX1 $T=193200 105280 0 0 $X=192770 $Y=104640
X261 1 2 647 648 DLY1JI3VX1 $T=197680 123200 1 0 $X=197250 $Y=118080
X262 1 2 649 650 DLY1JI3VX1 $T=197680 132160 0 0 $X=197250 $Y=131520
X263 1 2 SPI_CS 457 DLY1JI3VX1 $T=201600 212800 0 0 $X=201170 $Y=212160
X264 1 2 651 652 DLY1JI3VX1 $T=210000 42560 0 0 $X=209570 $Y=41920
X265 1 2 653 654 DLY1JI3VX1 $T=215600 51520 0 0 $X=215170 $Y=50880
X266 1 2 655 656 DLY1JI3VX1 $T=217840 42560 1 0 $X=217410 $Y=37440
X267 1 2 657 658 DLY1JI3VX1 $T=217840 60480 1 0 $X=217410 $Y=55360
X268 1 2 659 660 DLY1JI3VX1 $T=231840 33600 0 0 $X=231410 $Y=32960
X269 1 2 661 662 DLY1JI3VX1 $T=231840 42560 0 0 $X=231410 $Y=41920
X270 1 2 663 664 DLY1JI3VX1 $T=234080 168000 1 0 $X=233650 $Y=162880
X271 1 2 665 666 DLY1JI3VX1 $T=235200 168000 0 0 $X=234770 $Y=167360
X272 1 2 667 668 DLY1JI3VX1 $T=236320 150080 1 0 $X=235890 $Y=144960
X273 1 2 669 670 DLY1JI3VX1 $T=238000 141120 1 0 $X=237570 $Y=136000
X274 1 2 671 672 DLY1JI3VX1 $T=244160 33600 0 0 $X=243730 $Y=32960
X275 1 2 673 674 DLY1JI3VX1 $T=245280 141120 1 0 $X=244850 $Y=136000
X276 1 2 675 676 DLY1JI3VX1 $T=246960 33600 1 0 $X=246530 $Y=28480
X277 1 2 677 678 DLY1JI3VX1 $T=253120 78400 0 0 $X=252690 $Y=77760
X278 1 2 679 680 DLY1JI3VX1 $T=254240 42560 0 0 $X=253810 $Y=41920
X279 1 2 681 682 DLY1JI3VX1 $T=255360 159040 0 0 $X=254930 $Y=158400
X280 1 2 683 684 DLY1JI3VX1 $T=260960 42560 0 0 $X=260530 $Y=41920
X281 1 2 685 686 DLY1JI3VX1 $T=265440 150080 1 0 $X=265010 $Y=144960
X282 1 2 687 688 DLY1JI3VX1 $T=266560 42560 0 0 $X=266130 $Y=41920
X283 1 2 689 690 DLY1JI3VX1 $T=270480 168000 1 0 $X=270050 $Y=162880
X284 1 2 691 692 DLY1JI3VX1 $T=272160 132160 0 0 $X=271730 $Y=131520
X285 1 2 693 694 DLY1JI3VX1 $T=273840 42560 0 0 $X=273410 $Y=41920
X286 1 2 695 696 DLY1JI3VX1 $T=277760 150080 0 0 $X=277330 $Y=149440
X287 1 2 697 698 DLY1JI3VX1 $T=283920 69440 0 0 $X=283490 $Y=68800
X288 1 2 699 700 DLY1JI3VX1 $T=286160 168000 0 0 $X=285730 $Y=167360
X289 1 2 701 702 DLY1JI3VX1 $T=288400 114240 0 0 $X=287970 $Y=113600
X290 1 2 703 704 DLY1JI3VX1 $T=289520 42560 0 0 $X=289090 $Y=41920
X291 1 2 705 706 DLY1JI3VX1 $T=289520 69440 0 0 $X=289090 $Y=68800
X292 1 2 707 708 DLY1JI3VX1 $T=293440 159040 1 0 $X=293010 $Y=153920
X293 1 2 709 710 DLY1JI3VX1 $T=297920 42560 0 0 $X=297490 $Y=41920
X294 1 2 711 712 DLY1JI3VX1 $T=303520 42560 0 0 $X=303090 $Y=41920
X295 1 2 713 714 DLY1JI3VX1 $T=303520 159040 1 0 $X=303090 $Y=153920
X296 1 2 715 716 DLY1JI3VX1 $T=304640 33600 0 0 $X=304210 $Y=32960
X297 1 2 717 718 DLY1JI3VX1 $T=309120 42560 0 0 $X=308690 $Y=41920
X298 1 2 719 720 DLY1JI3VX1 $T=309680 159040 0 0 $X=309250 $Y=158400
X299 1 2 721 722 DLY1JI3VX1 $T=315280 42560 0 0 $X=314850 $Y=41920
X300 1 2 723 724 DLY1JI3VX1 $T=316400 159040 1 0 $X=315970 $Y=153920
X301 1 2 725 726 DLY1JI3VX1 $T=320880 42560 0 0 $X=320450 $Y=41920
X302 1 2 727 728 DLY1JI3VX1 $T=327040 42560 1 0 $X=326610 $Y=37440
X303 1 2 729 730 DLY1JI3VX1 $T=327040 60480 0 0 $X=326610 $Y=59840
X304 1 2 731 732 DLY1JI3VX1 $T=336000 42560 1 180 $X=329970 $Y=41920
X305 1 2 733 734 DLY1JI3VX1 $T=336000 42560 0 0 $X=335570 $Y=41920
X306 1 2 735 736 DLY1JI3VX1 $T=337680 141120 0 0 $X=337250 $Y=140480
X307 1 2 737 738 DLY1JI3VX1 $T=347760 176960 0 180 $X=341730 $Y=171840
X308 1 2 739 740 DLY1JI3VX1 $T=342720 51520 0 0 $X=342290 $Y=50880
X309 1 2 741 742 DLY1JI3VX1 $T=352240 60480 0 180 $X=346210 $Y=55360
X310 1 2 743 744 DLY1JI3VX1 $T=352240 141120 1 180 $X=346210 $Y=140480
X311 1 2 745 746 DLY1JI3VX1 $T=360080 150080 1 0 $X=359650 $Y=144960
X312 1 2 747 748 DLY1JI3VX1 $T=364560 168000 0 0 $X=364130 $Y=167360
X313 1 2 749 750 DLY1JI3VX1 $T=365680 150080 1 0 $X=365250 $Y=144960
X314 1 2 751 752 DLY1JI3VX1 $T=371840 33600 0 0 $X=371410 $Y=32960
X315 1 2 753 754 DLY1JI3VX1 $T=379120 141120 0 180 $X=373090 $Y=136000
X316 1 2 755 756 DLY1JI3VX1 $T=373520 159040 0 0 $X=373090 $Y=158400
X317 1 2 757 758 DLY1JI3VX1 $T=374080 33600 1 0 $X=373650 $Y=28480
X318 1 2 759 760 DLY1JI3VX1 $T=374080 132160 0 0 $X=373650 $Y=131520
X319 1 2 761 762 DLY1JI3VX1 $T=375200 185920 1 0 $X=374770 $Y=180800
X320 1 2 763 764 DLY1JI3VX1 $T=379680 33600 0 0 $X=379250 $Y=32960
X321 1 2 765 766 DLY1JI3VX1 $T=385840 24640 1 0 $X=385410 $Y=19520
X322 1 2 767 768 DLY1JI3VX1 $T=388640 33600 1 0 $X=388210 $Y=28480
X323 1 2 769 770 DLY1JI3VX1 $T=389760 78400 1 0 $X=389330 $Y=73280
X324 1 2 771 772 DLY1JI3VX1 $T=407680 33600 0 0 $X=407250 $Y=32960
X325 1 2 773 774 DLY1JI3VX1 $T=413280 42560 0 0 $X=412850 $Y=41920
X326 1 2 775 776 DLY1JI3VX1 $T=413280 51520 1 0 $X=412850 $Y=46400
X327 1 2 777 778 DLY1JI3VX1 $T=413280 51520 0 0 $X=412850 $Y=50880
X328 1 2 431 423 779 421 422 OR4JI3VX1 $T=184240 24640 0 0 $X=183810 $Y=24000
X329 1 2 436 432 780 433 438 OR4JI3VX1 $T=199920 24640 0 180 $X=193330 $Y=19520
X330 1 2 435 424 781 437 439 OR4JI3VX1 $T=206080 24640 0 0 $X=205650 $Y=24000
X331 1 2 392 782 95 386 383 OR4JI3VX1 $T=366800 24640 1 180 $X=360210 $Y=24000
X332 1 2 783 784 118 271 DFRRQJI3VX1 $T=21280 176960 1 0 $X=20850 $Y=171840
X333 1 2 783 785 118 242 DFRRQJI3VX1 $T=21840 159040 0 0 $X=21410 $Y=158400
X334 1 2 783 786 118 787 DFRRQJI3VX1 $T=21840 185920 1 0 $X=21410 $Y=180800
X335 1 2 783 788 118 461 DFRRQJI3VX1 $T=22400 150080 1 0 $X=21970 $Y=144960
X336 1 2 783 789 118 84 DFRRQJI3VX1 $T=22960 194880 1 0 $X=22530 $Y=189760
X337 1 2 783 790 118 539 DFRRQJI3VX1 $T=39200 105280 0 180 $X=23650 $Y=100160
X338 1 2 783 791 118 537 DFRRQJI3VX1 $T=39760 105280 1 180 $X=24210 $Y=104640
X339 1 2 783 792 118 541 DFRRQJI3VX1 $T=39760 114240 0 180 $X=24210 $Y=109120
X340 1 2 783 540 118 793 DFRRQJI3VX1 $T=24640 123200 0 0 $X=24210 $Y=122560
X341 1 2 783 542 118 794 DFRRQJI3VX1 $T=24640 132160 1 0 $X=24210 $Y=127040
X342 1 2 783 538 118 440 DFRRQJI3VX1 $T=24640 132160 0 0 $X=24210 $Y=131520
X343 1 2 783 463 118 323 DFRRQJI3VX1 $T=39200 150080 1 0 $X=38770 $Y=144960
X344 1 2 783 795 118 543 DFRRQJI3VX1 $T=54880 114240 1 180 $X=39330 $Y=113600
X345 1 2 783 544 118 796 DFRRQJI3VX1 $T=39760 141120 1 0 $X=39330 $Y=136000
X346 1 2 783 546 118 797 DFRRQJI3VX1 $T=39760 141120 0 0 $X=39330 $Y=140480
X347 1 2 783 798 118 87 DFRRQJI3VX1 $T=39760 194880 1 0 $X=39330 $Y=189760
X348 1 2 783 799 118 545 DFRRQJI3VX1 $T=56000 123200 0 180 $X=40450 $Y=118080
X349 1 2 783 800 118 549 DFRRQJI3VX1 $T=57120 132160 0 180 $X=41570 $Y=127040
X350 1 2 783 550 118 801 DFRRQJI3VX1 $T=42000 132160 0 0 $X=41570 $Y=131520
X351 1 2 802 548 118 803 DFRRQJI3VX1 $T=44800 42560 1 0 $X=44370 $Y=37440
X352 1 2 802 552 118 804 DFRRQJI3VX1 $T=44800 42560 0 0 $X=44370 $Y=41920
X353 1 2 802 805 118 547 DFRRQJI3VX1 $T=44800 51520 1 0 $X=44370 $Y=46400
X354 1 2 802 806 118 551 DFRRQJI3VX1 $T=44800 51520 0 0 $X=44370 $Y=50880
X355 1 2 802 807 118 559 DFRRQJI3VX1 $T=45360 60480 1 0 $X=44930 $Y=55360
X356 1 2 802 808 118 553 DFRRQJI3VX1 $T=45920 69440 1 0 $X=45490 $Y=64320
X357 1 2 783 809 118 810 DFRRQJI3VX1 $T=62720 194880 1 180 $X=47170 $Y=194240
X358 1 2 783 811 118 465 DFRRQJI3VX1 $T=50960 203840 1 0 $X=50530 $Y=198720
X359 1 2 783 812 118 563 DFRRQJI3VX1 $T=57120 141120 1 0 $X=56690 $Y=136000
X360 1 2 783 564 118 813 DFRRQJI3VX1 $T=72240 141120 1 180 $X=56690 $Y=140480
X361 1 2 783 558 118 814 DFRRQJI3VX1 $T=72240 150080 0 180 $X=56690 $Y=144960
X362 1 2 783 815 118 285 DFRRQJI3VX1 $T=58240 203840 0 0 $X=57810 $Y=203200
X363 1 2 802 560 118 816 DFRRQJI3VX1 $T=62160 51520 1 0 $X=61730 $Y=46400
X364 1 2 802 817 118 555 DFRRQJI3VX1 $T=62160 60480 1 0 $X=61730 $Y=55360
X365 1 2 802 554 118 818 DFRRQJI3VX1 $T=62720 42560 1 0 $X=62290 $Y=37440
X366 1 2 802 556 118 819 DFRRQJI3VX1 $T=62720 42560 0 0 $X=62290 $Y=41920
X367 1 2 802 820 118 565 DFRRQJI3VX1 $T=63280 60480 0 0 $X=62850 $Y=59840
X368 1 2 802 821 118 567 DFRRQJI3VX1 $T=63840 51520 0 0 $X=63410 $Y=50880
X369 1 2 783 822 118 577 DFRRQJI3VX1 $T=72240 168000 1 0 $X=71810 $Y=162880
X370 1 2 783 578 118 823 DFRRQJI3VX1 $T=87360 168000 1 180 $X=71810 $Y=167360
X371 1 2 783 824 118 557 DFRRQJI3VX1 $T=89040 141120 0 180 $X=73490 $Y=136000
X372 1 2 783 580 118 498 DFRRQJI3VX1 $T=89040 150080 0 180 $X=73490 $Y=144960
X373 1 2 783 329 118 284 DFRRQJI3VX1 $T=89600 203840 1 180 $X=74050 $Y=203200
X374 1 2 783 570 118 825 DFRRQJI3VX1 $T=90160 185920 0 180 $X=74610 $Y=180800
X375 1 2 783 826 118 581 DFRRQJI3VX1 $T=75040 212800 1 0 $X=74610 $Y=207680
X376 1 2 783 827 118 569 DFRRQJI3VX1 $T=75600 176960 1 0 $X=75170 $Y=171840
X377 1 2 783 576 118 828 DFRRQJI3VX1 $T=90720 176960 1 180 $X=75170 $Y=176320
X378 1 2 783 829 118 282 DFRRQJI3VX1 $T=90720 194880 1 180 $X=75170 $Y=194240
X379 1 2 802 830 118 561 DFRRQJI3VX1 $T=78400 60480 0 0 $X=77970 $Y=59840
X380 1 2 802 568 118 831 DFRRQJI3VX1 $T=78960 51520 1 0 $X=78530 $Y=46400
X381 1 2 802 566 118 832 DFRRQJI3VX1 $T=78960 51520 0 0 $X=78530 $Y=50880
X382 1 2 802 562 118 833 DFRRQJI3VX1 $T=78960 60480 1 0 $X=78530 $Y=55360
X383 1 2 802 834 118 571 DFRRQJI3VX1 $T=100240 78400 1 180 $X=84690 $Y=77760
X384 1 2 802 835 118 579 DFRRQJI3VX1 $T=100240 141120 1 180 $X=84690 $Y=140480
X385 1 2 783 836 118 573 DFRRQJI3VX1 $T=100240 194880 0 180 $X=84690 $Y=189760
X386 1 2 783 582 118 837 DFRRQJI3VX1 $T=100240 212800 1 180 $X=84690 $Y=212160
X387 1 2 838 594 118 839 DFRRQJI3VX1 $T=98560 42560 1 0 $X=98130 $Y=37440
X388 1 2 838 600 118 840 DFRRQJI3VX1 $T=98560 42560 0 0 $X=98130 $Y=41920
X389 1 2 802 841 118 593 DFRRQJI3VX1 $T=98560 51520 1 0 $X=98130 $Y=46400
X390 1 2 802 586 118 842 DFRRQJI3VX1 $T=98560 51520 0 0 $X=98130 $Y=50880
X391 1 2 802 843 118 599 DFRRQJI3VX1 $T=98560 60480 1 0 $X=98130 $Y=55360
X392 1 2 802 844 118 585 DFRRQJI3VX1 $T=98560 60480 0 0 $X=98130 $Y=59840
X393 1 2 783 845 118 591 DFRRQJI3VX1 $T=98560 150080 1 0 $X=98130 $Y=144960
X394 1 2 783 846 118 575 DFRRQJI3VX1 $T=98560 168000 0 0 $X=98130 $Y=167360
X395 1 2 414 847 118 583 DFRRQJI3VX1 $T=98560 194880 0 0 $X=98130 $Y=194240
X396 1 2 415 584 118 181 DFRRQJI3VX1 $T=98560 212800 1 0 $X=98130 $Y=207680
X397 1 2 268 848 118 849 DFRRQJI3VX1 $T=100240 212800 0 0 $X=99810 $Y=212160
X398 1 2 802 850 118 587 DFRRQJI3VX1 $T=102480 123200 1 0 $X=102050 $Y=118080
X399 1 2 802 851 118 589 DFRRQJI3VX1 $T=103040 132160 0 0 $X=102610 $Y=131520
X400 1 2 456 588 121 168 DFRRQJI3VX1 $T=103600 150080 0 0 $X=103170 $Y=149440
X401 1 2 116 852 118 597 DFRRQJI3VX1 $T=104160 176960 1 0 $X=103730 $Y=171840
X402 1 2 115 590 118 172 DFRRQJI3VX1 $T=104720 141120 1 0 $X=104290 $Y=136000
X403 1 2 783 592 118 164 DFRRQJI3VX1 $T=104720 176960 0 0 $X=104290 $Y=176320
X404 1 2 416 853 118 180 DFRRQJI3VX1 $T=108640 203840 0 0 $X=108210 $Y=203200
X405 1 2 783 574 118 185 DFRRQJI3VX1 $T=109760 194880 1 0 $X=109330 $Y=189760
X406 1 2 838 572 118 854 DFRRQJI3VX1 $T=128800 51520 1 180 $X=113250 $Y=50880
X407 1 2 838 855 118 605 DFRRQJI3VX1 $T=128800 60480 0 180 $X=113250 $Y=55360
X408 1 2 838 856 118 603 DFRRQJI3VX1 $T=113680 60480 0 0 $X=113250 $Y=59840
X409 1 2 783 857 118 184 DFRRQJI3VX1 $T=113680 194880 0 0 $X=113250 $Y=194240
X410 1 2 838 606 118 858 DFRRQJI3VX1 $T=114240 42560 1 0 $X=113810 $Y=37440
X411 1 2 838 859 118 609 DFRRQJI3VX1 $T=114240 42560 0 0 $X=113810 $Y=41920
X412 1 2 838 860 118 595 DFRRQJI3VX1 $T=129360 51520 0 180 $X=113810 $Y=46400
X413 1 2 838 596 118 861 DFRRQJI3VX1 $T=114800 33600 0 0 $X=114370 $Y=32960
X414 1 2 802 862 118 613 DFRRQJI3VX1 $T=118160 114240 0 0 $X=117730 $Y=113600
X415 1 2 802 863 118 601 DFRRQJI3VX1 $T=133280 123200 0 180 $X=117730 $Y=118080
X416 1 2 802 864 118 607 DFRRQJI3VX1 $T=119840 132160 0 0 $X=119410 $Y=131520
X417 1 2 802 865 118 171 DFRRQJI3VX1 $T=119840 141120 1 0 $X=119410 $Y=136000
X418 1 2 802 866 121 167 DFRRQJI3VX1 $T=119840 150080 0 0 $X=119410 $Y=149440
X419 1 2 419 598 118 177 DFRRQJI3VX1 $T=119840 176960 0 0 $X=119410 $Y=176320
X420 1 2 417 867 118 176 DFRRQJI3VX1 $T=121520 176960 1 0 $X=121090 $Y=171840
X421 1 2 418 868 118 163 DFRRQJI3VX1 $T=122080 168000 0 0 $X=121650 $Y=167360
X422 1 2 802 602 118 222 DFRRQJI3VX1 $T=123200 132160 1 0 $X=122770 $Y=127040
X423 1 2 838 291 119 869 DFRRQJI3VX1 $T=145600 105280 0 180 $X=130050 $Y=100160
X424 1 2 838 604 119 870 DFRRQJI3VX1 $T=131040 51520 1 0 $X=130610 $Y=46400
X425 1 2 838 612 119 871 DFRRQJI3VX1 $T=146160 51520 1 180 $X=130610 $Y=50880
X426 1 2 838 616 119 872 DFRRQJI3VX1 $T=146160 60480 0 180 $X=130610 $Y=55360
X427 1 2 838 873 119 611 DFRRQJI3VX1 $T=131040 60480 0 0 $X=130610 $Y=59840
X428 1 2 838 874 119 615 DFRRQJI3VX1 $T=131040 69440 1 0 $X=130610 $Y=64320
X429 1 2 838 610 119 875 DFRRQJI3VX1 $T=131600 42560 0 0 $X=131170 $Y=41920
X430 1 2 802 287 119 876 DFRRQJI3VX1 $T=148960 114240 0 180 $X=133410 $Y=109120
X431 1 2 802 608 121 212 DFRRQJI3VX1 $T=134960 141120 0 0 $X=134530 $Y=140480
X432 1 2 802 877 121 192 DFRRQJI3VX1 $T=135520 159040 1 0 $X=135090 $Y=153920
X433 1 2 802 614 121 878 DFRRQJI3VX1 $T=136080 141120 1 0 $X=135650 $Y=136000
X434 1 2 456 879 121 195 DFRRQJI3VX1 $T=136080 176960 0 0 $X=135650 $Y=176320
X435 1 2 456 880 121 204 DFRRQJI3VX1 $T=136640 194880 1 0 $X=136210 $Y=189760
X436 1 2 460 881 121 201 DFRRQJI3VX1 $T=138320 203840 0 0 $X=137890 $Y=203200
X437 1 2 838 471 119 882 DFRRQJI3VX1 $T=160160 96320 1 180 $X=144610 $Y=95680
X438 1 2 838 883 119 619 DFRRQJI3VX1 $T=145600 69440 0 0 $X=145170 $Y=68800
X439 1 2 838 884 119 885 DFRRQJI3VX1 $T=160720 105280 0 180 $X=145170 $Y=100160
X440 1 2 838 886 119 621 DFRRQJI3VX1 $T=147280 69440 1 0 $X=146850 $Y=64320
X441 1 2 838 618 119 887 DFRRQJI3VX1 $T=147840 42560 0 0 $X=147410 $Y=41920
X442 1 2 838 622 119 888 DFRRQJI3VX1 $T=162960 51520 0 180 $X=147410 $Y=46400
X443 1 2 838 889 119 617 DFRRQJI3VX1 $T=162960 51520 1 180 $X=147410 $Y=50880
X444 1 2 838 620 119 890 DFRRQJI3VX1 $T=162960 60480 1 180 $X=147410 $Y=59840
X445 1 2 802 891 121 188 DFRRQJI3VX1 $T=151200 159040 1 0 $X=150770 $Y=153920
X446 1 2 802 892 121 207 DFRRQJI3VX1 $T=166320 168000 1 180 $X=150770 $Y=167360
X447 1 2 456 893 121 198 DFRRQJI3VX1 $T=166320 176960 1 180 $X=150770 $Y=176320
X448 1 2 802 894 121 211 DFRRQJI3VX1 $T=166880 150080 0 180 $X=151330 $Y=144960
X449 1 2 460 895 121 507 DFRRQJI3VX1 $T=151760 185920 1 0 $X=151330 $Y=180800
X450 1 2 460 896 121 897 DFRRQJI3VX1 $T=152320 185920 0 0 $X=151890 $Y=185280
X451 1 2 460 898 121 509 DFRRQJI3VX1 $T=152320 194880 1 0 $X=151890 $Y=189760
X452 1 2 460 899 121 472 DFRRQJI3VX1 $T=170800 203840 1 180 $X=155250 $Y=203200
X453 1 2 838 624 119 469 DFRRQJI3VX1 $T=173600 105280 1 180 $X=158050 $Y=104640
X454 1 2 838 900 121 221 DFRRQJI3VX1 $T=159040 132160 0 0 $X=158610 $Y=131520
X455 1 2 838 901 119 902 DFRRQJI3VX1 $T=175840 105280 0 180 $X=160290 $Y=100160
X456 1 2 460 903 121 904 DFRRQJI3VX1 $T=160720 212800 0 0 $X=160290 $Y=212160
X457 1 2 838 905 119 623 DFRRQJI3VX1 $T=176960 96320 1 180 $X=161410 $Y=95680
X458 1 2 838 906 119 625 DFRRQJI3VX1 $T=163520 69440 1 0 $X=163090 $Y=64320
X459 1 2 838 626 119 907 DFRRQJI3VX1 $T=179200 42560 0 180 $X=163650 $Y=37440
X460 1 2 838 634 119 908 DFRRQJI3VX1 $T=179760 42560 1 180 $X=164210 $Y=41920
X461 1 2 838 909 119 633 DFRRQJI3VX1 $T=164640 60480 1 0 $X=164210 $Y=55360
X462 1 2 838 628 119 910 DFRRQJI3VX1 $T=180320 51520 0 180 $X=164770 $Y=46400
X463 1 2 838 911 119 627 DFRRQJI3VX1 $T=165200 51520 0 0 $X=164770 $Y=50880
X464 1 2 802 912 121 217 DFRRQJI3VX1 $T=181440 168000 0 180 $X=165890 $Y=162880
X465 1 2 802 913 121 914 DFRRQJI3VX1 $T=183120 159040 0 180 $X=167570 $Y=153920
X466 1 2 838 632 119 467 DFRRQJI3VX1 $T=188160 114240 0 180 $X=172610 $Y=109120
X467 1 2 838 915 121 916 DFRRQJI3VX1 $T=189840 132160 1 180 $X=174290 $Y=131520
X468 1 2 838 640 119 474 DFRRQJI3VX1 $T=190400 105280 1 180 $X=174850 $Y=104640
X469 1 2 838 917 119 918 DFRRQJI3VX1 $T=190960 105280 0 180 $X=175410 $Y=100160
X470 1 2 460 919 121 920 DFRRQJI3VX1 $T=176960 212800 0 0 $X=176530 $Y=212160
X471 1 2 838 630 121 333 DFRRQJI3VX1 $T=193200 141120 1 180 $X=177650 $Y=140480
X472 1 2 838 638 119 921 DFRRQJI3VX1 $T=197120 42560 1 180 $X=181570 $Y=41920
X473 1 2 838 642 119 922 DFRRQJI3VX1 $T=197680 51520 0 180 $X=182130 $Y=46400
X474 1 2 838 923 119 641 DFRRQJI3VX1 $T=182560 51520 0 0 $X=182130 $Y=50880
X475 1 2 838 924 119 637 DFRRQJI3VX1 $T=182560 60480 1 0 $X=182130 $Y=55360
X476 1 2 838 648 119 925 DFRRQJI3VX1 $T=197680 123200 0 180 $X=182130 $Y=118080
X477 1 2 459 636 121 227 DFRRQJI3VX1 $T=197680 150080 0 180 $X=182130 $Y=144960
X478 1 2 459 644 121 330 DFRRQJI3VX1 $T=198240 150080 1 180 $X=182690 $Y=149440
X479 1 2 838 646 119 926 DFRRQJI3VX1 $T=198800 114240 1 180 $X=183250 $Y=113600
X480 1 2 459 335 121 513 DFRRQJI3VX1 $T=183680 159040 1 0 $X=183250 $Y=153920
X481 1 2 459 927 121 928 DFRRQJI3VX1 $T=184240 168000 1 0 $X=183810 $Y=162880
X482 1 2 838 929 119 639 DFRRQJI3VX1 $T=203280 87360 1 180 $X=187730 $Y=86720
X483 1 2 838 930 119 631 DFRRQJI3VX1 $T=203280 96320 0 180 $X=187730 $Y=91200
X484 1 2 838 931 119 645 DFRRQJI3VX1 $T=203280 114240 0 180 $X=187730 $Y=109120
X485 1 2 838 650 121 932 DFRRQJI3VX1 $T=203280 123200 1 180 $X=187730 $Y=122560
X486 1 2 838 933 121 649 DFRRQJI3VX1 $T=203280 132160 0 180 $X=187730 $Y=127040
X487 1 2 420 341 121 158 DFRRQJI3VX1 $T=192640 168000 0 0 $X=192210 $Y=167360
X488 1 2 460 934 121 511 DFRRQJI3VX1 $T=208320 212800 0 180 $X=192770 $Y=207680
X489 1 2 459 935 121 663 DFRRQJI3VX1 $T=198240 150080 1 0 $X=197810 $Y=144960
X490 1 2 459 936 121 667 DFRRQJI3VX1 $T=198240 150080 0 0 $X=197810 $Y=149440
X491 1 2 459 937 119 653 DFRRQJI3VX1 $T=199920 69440 1 0 $X=199490 $Y=64320
X492 1 2 838 938 119 647 DFRRQJI3VX1 $T=215040 114240 1 180 $X=199490 $Y=113600
X493 1 2 838 652 119 939 DFRRQJI3VX1 $T=215600 51520 0 180 $X=200050 $Y=46400
X494 1 2 838 654 119 940 DFRRQJI3VX1 $T=215600 51520 1 180 $X=200050 $Y=50880
X495 1 2 459 941 119 651 DFRRQJI3VX1 $T=201040 60480 0 0 $X=200610 $Y=59840
X496 1 2 942 658 119 943 DFRRQJI3VX1 $T=202720 60480 1 0 $X=202290 $Y=55360
X497 1 2 427 944 121 157 DFRRQJI3VX1 $T=204400 176960 0 0 $X=203970 $Y=176320
X498 1 2 459 945 119 657 DFRRQJI3VX1 $T=223440 69440 1 180 $X=207890 $Y=68800
X499 1 2 460 946 121 346 DFRRQJI3VX1 $T=225680 212800 0 180 $X=210130 $Y=207680
X500 1 2 459 947 121 669 DFRRQJI3VX1 $T=228480 141120 0 180 $X=212930 $Y=136000
X501 1 2 459 948 121 635 DFRRQJI3VX1 $T=228480 141120 1 180 $X=212930 $Y=140480
X502 1 2 459 949 121 629 DFRRQJI3VX1 $T=228480 150080 0 180 $X=212930 $Y=144960
X503 1 2 430 950 121 643 DFRRQJI3VX1 $T=228480 150080 1 180 $X=212930 $Y=149440
X504 1 2 942 666 121 510 DFRRQJI3VX1 $T=228480 159040 1 180 $X=212930 $Y=158400
X505 1 2 942 656 119 951 DFRRQJI3VX1 $T=226800 42560 1 0 $X=226370 $Y=37440
X506 1 2 942 660 119 952 DFRRQJI3VX1 $T=226800 51520 1 0 $X=226370 $Y=46400
X507 1 2 942 662 119 953 DFRRQJI3VX1 $T=226800 51520 0 0 $X=226370 $Y=50880
X508 1 2 942 954 119 661 DFRRQJI3VX1 $T=226800 60480 1 0 $X=226370 $Y=55360
X509 1 2 942 955 119 659 DFRRQJI3VX1 $T=226800 60480 0 0 $X=226370 $Y=59840
X510 1 2 942 956 119 655 DFRRQJI3VX1 $T=226800 69440 1 0 $X=226370 $Y=64320
X511 1 2 123 957 121 159 DFRRQJI3VX1 $T=226800 176960 0 0 $X=226370 $Y=176320
X512 1 2 123 958 121 959 DFRRQJI3VX1 $T=226800 185920 1 0 $X=226370 $Y=180800
X513 1 2 123 355 121 960 DFRRQJI3VX1 $T=226800 194880 1 0 $X=226370 $Y=189760
X514 1 2 123 352 121 961 DFRRQJI3VX1 $T=226800 203840 0 0 $X=226370 $Y=203200
X515 1 2 123 962 121 482 DFRRQJI3VX1 $T=229600 212800 1 0 $X=229170 $Y=207680
X516 1 2 123 664 121 356 DFRRQJI3VX1 $T=230720 159040 1 0 $X=230290 $Y=153920
X517 1 2 123 668 121 963 DFRRQJI3VX1 $T=231280 150080 0 0 $X=230850 $Y=149440
X518 1 2 123 670 121 233 DFRRQJI3VX1 $T=232960 141120 0 0 $X=232530 $Y=140480
X519 1 2 964 965 119 673 DFRRQJI3VX1 $T=236320 114240 1 0 $X=235890 $Y=109120
X520 1 2 434 966 121 685 DFRRQJI3VX1 $T=236880 132160 0 0 $X=236450 $Y=131520
X521 1 2 942 672 119 967 DFRRQJI3VX1 $T=239120 42560 0 0 $X=238690 $Y=41920
X522 1 2 964 968 121 691 DFRRQJI3VX1 $T=240240 123200 0 0 $X=239810 $Y=122560
X523 1 2 964 674 121 969 DFRRQJI3VX1 $T=240240 132160 1 0 $X=239810 $Y=127040
X524 1 2 123 970 121 485 DFRRQJI3VX1 $T=240240 203840 1 0 $X=239810 $Y=198720
X525 1 2 942 676 119 971 DFRRQJI3VX1 $T=241920 42560 1 0 $X=241490 $Y=37440
X526 1 2 942 680 119 972 DFRRQJI3VX1 $T=257040 51520 0 180 $X=241490 $Y=46400
X527 1 2 942 973 119 679 DFRRQJI3VX1 $T=241920 51520 0 0 $X=241490 $Y=50880
X528 1 2 942 678 119 974 DFRRQJI3VX1 $T=257040 60480 0 180 $X=241490 $Y=55360
X529 1 2 942 975 119 675 DFRRQJI3VX1 $T=257040 60480 1 180 $X=241490 $Y=59840
X530 1 2 942 976 119 671 DFRRQJI3VX1 $T=257040 69440 0 180 $X=241490 $Y=64320
X531 1 2 123 977 121 978 DFRRQJI3VX1 $T=259840 203840 1 180 $X=244290 $Y=203200
X532 1 2 123 686 121 979 DFRRQJI3VX1 $T=261520 150080 1 180 $X=245970 $Y=149440
X533 1 2 123 682 121 980 DFRRQJI3VX1 $T=261520 159040 0 180 $X=245970 $Y=153920
X534 1 2 123 981 121 982 DFRRQJI3VX1 $T=249200 212800 1 0 $X=248770 $Y=207680
X535 1 2 123 983 121 665 DFRRQJI3VX1 $T=265440 150080 0 180 $X=249890 $Y=144960
X536 1 2 942 984 119 677 DFRRQJI3VX1 $T=252000 69440 0 0 $X=251570 $Y=68800
X537 1 2 964 692 121 985 DFRRQJI3VX1 $T=272160 132160 0 180 $X=256610 $Y=127040
X538 1 2 942 688 119 986 DFRRQJI3VX1 $T=272720 51520 0 180 $X=257170 $Y=46400
X539 1 2 942 694 119 987 DFRRQJI3VX1 $T=257600 51520 0 0 $X=257170 $Y=50880
X540 1 2 942 988 119 687 DFRRQJI3VX1 $T=257600 60480 0 0 $X=257170 $Y=59840
X541 1 2 942 989 119 693 DFRRQJI3VX1 $T=272720 69440 0 180 $X=257170 $Y=64320
X542 1 2 942 684 119 990 DFRRQJI3VX1 $T=258160 60480 1 0 $X=257730 $Y=55360
X543 1 2 964 991 121 695 DFRRQJI3VX1 $T=259280 123200 0 0 $X=258850 $Y=122560
X544 1 2 964 992 119 689 DFRRQJI3VX1 $T=259840 123200 1 0 $X=259410 $Y=118080
X545 1 2 123 690 121 993 DFRRQJI3VX1 $T=276080 159040 1 180 $X=260530 $Y=158400
X546 1 2 123 994 121 995 DFRRQJI3VX1 $T=276080 203840 1 180 $X=260530 $Y=203200
X547 1 2 123 696 121 996 DFRRQJI3VX1 $T=277200 159040 0 180 $X=261650 $Y=153920
X548 1 2 123 997 121 681 DFRRQJI3VX1 $T=277760 150080 1 180 $X=262210 $Y=149440
X549 1 2 942 998 119 683 DFRRQJI3VX1 $T=282240 69440 1 180 $X=266690 $Y=68800
X550 1 2 942 698 119 999 DFRRQJI3VX1 $T=291200 51520 0 180 $X=275650 $Y=46400
X551 1 2 942 704 119 1000 DFRRQJI3VX1 $T=291200 51520 1 180 $X=275650 $Y=50880
X552 1 2 942 706 119 1001 DFRRQJI3VX1 $T=291200 60480 0 180 $X=275650 $Y=55360
X553 1 2 942 1002 119 703 DFRRQJI3VX1 $T=276080 60480 0 0 $X=275650 $Y=59840
X554 1 2 942 1003 119 705 DFRRQJI3VX1 $T=276080 69440 1 0 $X=275650 $Y=64320
X555 1 2 942 1004 119 697 DFRRQJI3VX1 $T=276640 96320 1 0 $X=276210 $Y=91200
X556 1 2 964 702 121 154 DFRRQJI3VX1 $T=291760 123200 0 180 $X=276210 $Y=118080
X557 1 2 964 1005 121 701 DFRRQJI3VX1 $T=277200 123200 0 0 $X=276770 $Y=122560
X558 1 2 123 1006 121 1007 DFRRQJI3VX1 $T=292320 194880 1 180 $X=276770 $Y=194240
X559 1 2 964 1008 121 707 DFRRQJI3VX1 $T=277760 159040 0 0 $X=277330 $Y=158400
X560 1 2 964 1009 121 699 DFRRQJI3VX1 $T=278320 159040 1 0 $X=277890 $Y=153920
X561 1 2 123 708 121 527 DFRRQJI3VX1 $T=293440 168000 0 180 $X=277890 $Y=162880
X562 1 2 123 700 121 528 DFRRQJI3VX1 $T=295120 176960 0 180 $X=279570 $Y=171840
X563 1 2 123 1010 121 529 DFRRQJI3VX1 $T=295120 194880 0 180 $X=279570 $Y=189760
X564 1 2 964 1011 122 713 DFRRQJI3VX1 $T=292320 150080 0 0 $X=291890 $Y=149440
X565 1 2 942 710 119 1012 DFRRQJI3VX1 $T=309120 51520 0 180 $X=293570 $Y=46400
X566 1 2 942 718 119 1013 DFRRQJI3VX1 $T=309120 51520 1 180 $X=293570 $Y=50880
X567 1 2 942 712 119 1014 DFRRQJI3VX1 $T=309120 60480 0 180 $X=293570 $Y=55360
X568 1 2 942 1015 119 709 DFRRQJI3VX1 $T=294000 60480 0 0 $X=293570 $Y=59840
X569 1 2 942 1016 119 711 DFRRQJI3VX1 $T=294000 69440 1 0 $X=293570 $Y=64320
X570 1 2 964 714 122 515 DFRRQJI3VX1 $T=309120 159040 1 180 $X=293570 $Y=158400
X571 1 2 942 1017 119 717 DFRRQJI3VX1 $T=294560 78400 1 0 $X=294130 $Y=73280
X572 1 2 942 716 119 1018 DFRRQJI3VX1 $T=310240 42560 0 180 $X=294690 $Y=37440
X573 1 2 942 1019 119 715 DFRRQJI3VX1 $T=295120 69440 0 0 $X=294690 $Y=68800
X574 1 2 108 493 110 90 DFRRQJI3VX1 $T=297360 212800 1 0 $X=296930 $Y=207680
X575 1 2 964 1020 122 723 DFRRQJI3VX1 $T=307440 150080 0 0 $X=307010 $Y=149440
X576 1 2 942 726 122 1021 DFRRQJI3VX1 $T=326480 51520 0 180 $X=310930 $Y=46400
X577 1 2 942 722 122 1022 DFRRQJI3VX1 $T=326480 51520 1 180 $X=310930 $Y=50880
X578 1 2 942 730 122 1023 DFRRQJI3VX1 $T=326480 60480 0 180 $X=310930 $Y=55360
X579 1 2 942 1024 122 727 DFRRQJI3VX1 $T=326480 69440 0 180 $X=310930 $Y=64320
X580 1 2 964 1025 122 532 DFRRQJI3VX1 $T=311360 185920 1 0 $X=310930 $Y=180800
X581 1 2 942 728 122 1026 DFRRQJI3VX1 $T=311920 42560 1 0 $X=311490 $Y=37440
X582 1 2 942 1027 122 725 DFRRQJI3VX1 $T=327040 60480 1 180 $X=311490 $Y=59840
X583 1 2 942 1028 122 729 DFRRQJI3VX1 $T=311920 69440 0 0 $X=311490 $Y=68800
X584 1 2 942 1029 122 721 DFRRQJI3VX1 $T=311920 78400 1 0 $X=311490 $Y=73280
X585 1 2 964 1030 122 101 DFRRQJI3VX1 $T=311920 185920 0 0 $X=311490 $Y=185280
X586 1 2 108 413 110 494 DFRRQJI3VX1 $T=327600 203840 1 180 $X=312050 $Y=203200
X587 1 2 108 1031 110 256 DFRRQJI3VX1 $T=314720 203840 1 0 $X=314290 $Y=198720
X588 1 2 964 1032 122 735 DFRRQJI3VX1 $T=322000 132160 1 0 $X=321570 $Y=127040
X589 1 2 964 1033 122 759 DFRRQJI3VX1 $T=322000 132160 0 0 $X=321570 $Y=131520
X590 1 2 964 1034 122 719 DFRRQJI3VX1 $T=322000 141120 1 0 $X=321570 $Y=136000
X591 1 2 964 736 122 103 DFRRQJI3VX1 $T=337120 150080 0 180 $X=321570 $Y=144960
X592 1 2 964 724 122 238 DFRRQJI3VX1 $T=322000 159040 1 0 $X=321570 $Y=153920
X593 1 2 964 1035 122 749 DFRRQJI3VX1 $T=322560 141120 0 0 $X=322130 $Y=140480
X594 1 2 964 1036 122 753 DFRRQJI3VX1 $T=322560 150080 0 0 $X=322130 $Y=149440
X595 1 2 964 720 122 1037 DFRRQJI3VX1 $T=338240 159040 1 180 $X=322690 $Y=158400
X596 1 2 942 734 122 1038 DFRRQJI3VX1 $T=342720 51520 0 180 $X=327170 $Y=46400
X597 1 2 942 740 122 1039 DFRRQJI3VX1 $T=342720 51520 1 180 $X=327170 $Y=50880
X598 1 2 942 1040 122 733 DFRRQJI3VX1 $T=328160 60480 1 0 $X=327730 $Y=55360
X599 1 2 942 1041 122 739 DFRRQJI3VX1 $T=328160 69440 1 0 $X=327730 $Y=64320
X600 1 2 964 1042 122 536 DFRRQJI3VX1 $T=329280 185920 0 0 $X=328850 $Y=185280
X601 1 2 964 1043 122 1044 DFRRQJI3VX1 $T=329840 194880 0 0 $X=329410 $Y=194240
X602 1 2 108 1045 110 495 DFRRQJI3VX1 $T=336000 203840 0 0 $X=335570 $Y=203200
X603 1 2 964 1046 122 737 DFRRQJI3VX1 $T=355040 132160 0 180 $X=339490 $Y=127040
X604 1 2 964 738 122 1047 DFRRQJI3VX1 $T=355040 150080 1 180 $X=339490 $Y=149440
X605 1 2 964 744 122 452 DFRRQJI3VX1 $T=355040 159040 0 180 $X=339490 $Y=153920
X606 1 2 964 1048 122 745 DFRRQJI3VX1 $T=355600 132160 1 180 $X=340050 $Y=131520
X607 1 2 964 754 122 1049 DFRRQJI3VX1 $T=355600 141120 0 180 $X=340050 $Y=136000
X608 1 2 964 746 122 530 DFRRQJI3VX1 $T=355600 150080 0 180 $X=340050 $Y=144960
X609 1 2 964 732 122 1050 DFRRQJI3VX1 $T=356720 42560 1 180 $X=341170 $Y=41920
X610 1 2 964 1051 122 741 DFRRQJI3VX1 $T=356720 60480 1 180 $X=341170 $Y=59840
X611 1 2 964 742 122 1052 DFRRQJI3VX1 $T=355040 51520 0 0 $X=354610 $Y=50880
X612 1 2 128 1053 122 731 DFRRQJI3VX1 $T=355040 69440 1 0 $X=354610 $Y=64320
X613 1 2 128 1054 122 1055 DFRRQJI3VX1 $T=355040 194880 1 0 $X=354610 $Y=189760
X614 1 2 128 1056 122 1057 DFRRQJI3VX1 $T=355040 194880 0 0 $X=354610 $Y=194240
X615 1 2 128 1058 122 755 DFRRQJI3VX1 $T=357280 150080 0 0 $X=356850 $Y=149440
X616 1 2 128 1059 122 743 DFRRQJI3VX1 $T=357840 159040 1 0 $X=357410 $Y=153920
X617 1 2 128 1060 122 747 DFRRQJI3VX1 $T=358400 141120 1 0 $X=357970 $Y=136000
X618 1 2 128 750 122 105 DFRRQJI3VX1 $T=358400 141120 0 0 $X=357970 $Y=140480
X619 1 2 128 756 122 1061 DFRRQJI3VX1 $T=358400 159040 0 0 $X=357970 $Y=158400
X620 1 2 128 748 122 1062 DFRRQJI3VX1 $T=358400 168000 1 0 $X=357970 $Y=162880
X621 1 2 128 760 122 1063 DFRRQJI3VX1 $T=358960 132160 0 0 $X=358530 $Y=131520
X622 1 2 964 758 122 1064 DFRRQJI3VX1 $T=377440 42560 1 180 $X=361890 $Y=41920
X623 1 2 128 1065 122 757 DFRRQJI3VX1 $T=362320 60480 0 0 $X=361890 $Y=59840
X624 1 2 964 752 122 1066 DFRRQJI3VX1 $T=378000 51520 0 180 $X=362450 $Y=46400
X625 1 2 128 1067 122 751 DFRRQJI3VX1 $T=362880 60480 1 0 $X=362450 $Y=55360
X626 1 2 128 762 122 1068 DFRRQJI3VX1 $T=380800 176960 1 180 $X=365250 $Y=176320
X627 1 2 128 1069 122 761 DFRRQJI3VX1 $T=381360 176960 0 180 $X=365810 $Y=171840
X628 1 2 128 1070 122 1071 DFRRQJI3VX1 $T=388640 150080 1 180 $X=373090 $Y=149440
X629 1 2 128 764 122 1072 DFRRQJI3VX1 $T=394800 51520 0 180 $X=379250 $Y=46400
X630 1 2 128 766 122 1073 DFRRQJI3VX1 $T=395360 42560 0 180 $X=379810 $Y=37440
X631 1 2 128 768 122 1074 DFRRQJI3VX1 $T=395360 42560 1 180 $X=379810 $Y=41920
X632 1 2 128 770 122 1075 DFRRQJI3VX1 $T=395360 51520 1 180 $X=379810 $Y=50880
X633 1 2 128 1076 122 767 DFRRQJI3VX1 $T=380240 60480 1 0 $X=379810 $Y=55360
X634 1 2 128 1077 122 769 DFRRQJI3VX1 $T=380240 60480 0 0 $X=379810 $Y=59840
X635 1 2 128 1078 122 765 DFRRQJI3VX1 $T=380240 69440 1 0 $X=379810 $Y=64320
X636 1 2 128 1079 122 763 DFRRQJI3VX1 $T=380240 69440 0 0 $X=379810 $Y=68800
X637 1 2 128 1080 122 263 DFRRQJI3VX1 $T=408800 150080 1 180 $X=393250 $Y=149440
X638 1 2 128 1081 122 265 DFRRQJI3VX1 $T=409920 132160 0 180 $X=394370 $Y=127040
X639 1 2 128 772 122 1082 DFRRQJI3VX1 $T=413280 42560 0 180 $X=397730 $Y=37440
X640 1 2 128 774 122 1083 DFRRQJI3VX1 $T=413280 42560 1 180 $X=397730 $Y=41920
X641 1 2 128 776 122 1084 DFRRQJI3VX1 $T=413280 51520 0 180 $X=397730 $Y=46400
X642 1 2 128 778 122 1085 DFRRQJI3VX1 $T=413280 51520 1 180 $X=397730 $Y=50880
X643 1 2 128 1086 122 777 DFRRQJI3VX1 $T=398160 60480 1 0 $X=397730 $Y=55360
X644 1 2 128 1087 122 773 DFRRQJI3VX1 $T=398160 60480 0 0 $X=397730 $Y=59840
X645 1 2 128 1088 122 775 DFRRQJI3VX1 $T=398160 69440 1 0 $X=397730 $Y=64320
X646 1 2 128 1089 122 771 DFRRQJI3VX1 $T=398160 69440 0 0 $X=397730 $Y=68800
X647 1 2 128 1090 122 151 DFRRQJI3VX1 $T=398160 105280 1 0 $X=397730 $Y=100160
X648 1 2 461 1091 INJI3VX1 $T=42000 159040 1 0 $X=41570 $Y=153920
X649 1 2 84 1092 INJI3VX1 $T=42560 176960 0 0 $X=42130 $Y=176320
X650 1 2 87 441 INJI3VX1 $T=50960 176960 0 0 $X=50530 $Y=176320
X651 1 2 465 1093 INJI3VX1 $T=63840 194880 1 0 $X=63410 $Y=189760
X652 1 2 114 1094 INJI3VX1 $T=181440 150080 0 0 $X=181010 $Y=149440
X653 1 2 154 230 INJI3VX1 $T=202720 176960 0 0 $X=202290 $Y=176320
X654 1 2 114 1095 INJI3VX1 $T=231840 176960 1 0 $X=231410 $Y=171840
X655 1 2 1095 123 INJI3VX1 $T=233520 168000 0 0 $X=233090 $Y=167360
X656 1 2 482 357 INJI3VX1 $T=238560 203840 1 0 $X=238130 $Y=198720
X657 1 2 485 1096 INJI3VX1 $T=247520 185920 0 0 $X=247090 $Y=185280
X658 1 2 143 108 INJI3VX1 $T=309120 203840 0 0 $X=308690 $Y=203200
X659 1 2 265 1097 INJI3VX1 $T=392560 132160 1 0 $X=392130 $Y=127040
X660 1 2 1094 802 INJI3VX2 $T=180320 150080 1 0 $X=179890 $Y=144960
X661 1 2 1098 DAC<1> BUJI3VX12 $T=69440 24640 0 180 $X=56690 $Y=19520
X662 1 2 1099 DAC<2> BUJI3VX12 $T=77840 24640 1 180 $X=65090 $Y=24000
X663 1 2 1100 DAC<3> BUJI3VX12 $T=82880 24640 0 180 $X=70130 $Y=19520
X664 1 2 242 240 785 321 1101 ON22JI3VX1 $T=33600 159040 0 180 $X=28690 $Y=153920
X665 1 2 787 1102 1103 1104 271 ON22JI3VX1 $T=36400 168000 1 180 $X=31490 $Y=167360
X666 1 2 793 1105 1106 1092 794 ON22JI3VX1 $T=40320 168000 1 0 $X=39890 $Y=162880
X667 1 2 1107 499 809 273 1108 ON22JI3VX1 $T=58800 185920 1 180 $X=53890 $Y=185280
X668 1 2 813 1093 324 1109 823 ON22JI3VX1 $T=63280 168000 0 0 $X=62850 $Y=167360
X669 1 2 1109 328 815 273 1110 ON22JI3VX1 $T=71680 194880 0 180 $X=66770 $Y=189760
X670 1 2 1111 317 958 354 232 ON22JI3VX1 $T=246400 185920 0 180 $X=241490 $Y=180800
X671 1 2 1112 317 977 519 1113 ON22JI3VX1 $T=251440 194880 1 0 $X=251010 $Y=189760
X672 1 2 993 1114 1115 1116 996 ON22JI3VX1 $T=267680 185920 1 180 $X=262770 $Y=185280
X673 1 2 103 1117 1118 1119 1037 ON22JI3VX1 $T=319760 159040 1 180 $X=314850 $Y=158400
X674 1 2 536 453 1120 535 1044 ON22JI3VX1 $T=344960 185920 0 180 $X=340050 $Y=180800
X675 1 2 1068 1121 1122 1123 1062 ON22JI3VX1 $T=364560 168000 1 180 $X=359650 $Y=167360
X676 1 2 152 1124 406 1125 138 ON22JI3VX1 $T=392560 114240 0 180 $X=387650 $Y=109120
X677 1 2 239 104 1080 397 263 ON22JI3VX1 $T=398720 159040 1 0 $X=398290 $Y=153920
X678 1 2 304 512 339 1126 1127 AN31JI3VX1 $T=195440 185920 0 0 $X=195010 $Y=185280
X679 1 2 523 1128 364 1129 521 AN31JI3VX1 $T=264320 168000 0 0 $X=263890 $Y=167360
X680 1 2 1130 381 1131 1132 236 AN31JI3VX1 $T=313040 168000 0 180 $X=308690 $Y=162880
X681 1 2 245 250 1133 324 NO3JI3VX0 $T=63840 176960 1 0 $X=63410 $Y=171840
X682 1 2 358 313 359 1134 NO3JI3VX0 $T=246400 159040 0 0 $X=245970 $Y=158400
X683 1 2 1135 1136 1137 1138 NO3JI3VX0 $T=295120 212800 0 0 $X=294690 $Y=212160
X684 1 2 230 1139 1140 1141 NO3JI3VX0 $T=305200 176960 0 0 $X=304770 $Y=176320
X685 1 2 1142 780 1143 781 1144 OR4JI3VX2 $T=194320 24640 0 0 $X=193890 $Y=24000
X686 1 2 1145 837 849 179 HAJI3VX1 $T=138320 203840 1 180 $X=130050 $Y=203200
X687 1 2 1146 837 472 200 HAJI3VX1 $T=158480 212800 0 180 $X=150210 $Y=207680
X688 1 2 1147 447 507 1148 HAJI3VX1 $T=175840 185920 0 180 $X=167570 $Y=180800
X689 1 2 1149 1150 904 1151 HAJI3VX1 $T=173600 203840 0 0 $X=173170 $Y=203200
X690 1 2 1152 897 1148 1153 HAJI3VX1 $T=175280 185920 0 0 $X=174850 $Y=185280
X691 1 2 1154 920 1151 1155 HAJI3VX1 $T=186480 203840 0 0 $X=186050 $Y=203200
X692 1 2 1156 982 1157 1158 HAJI3VX1 $T=262080 194880 1 180 $X=253810 $Y=194240
X693 1 2 1159 995 1158 1160 HAJI3VX1 $T=267680 203840 0 180 $X=259410 $Y=198720
X694 1 2 1031 256 1161 411 HAJI3VX1 $T=316960 212800 1 0 $X=316530 $Y=207680
X695 1 2 1162 100 101 1163 HAJI3VX1 $T=322000 176960 0 0 $X=321570 $Y=176320
X696 1 2 109 111 1164 1161 HAJI3VX1 $T=329840 212800 0 0 $X=329410 $Y=212160
X697 1 2 1165 1057 1166 1167 HAJI3VX1 $T=351680 176960 1 180 $X=343410 $Y=176320
X698 1 2 487 1168 DLY4JI3VX1 $T=252000 212800 0 0 $X=251570 $Y=212160
X699 1 2 1169 276 1170 NO2I1JI3VX1 $T=50400 150080 0 0 $X=49970 $Y=149440
X700 1 2 467 502 192 NO2I1JI3VX1 $T=143360 123200 0 0 $X=142930 $Y=122560
X701 1 2 474 504 188 NO2I1JI3VX1 $T=166320 132160 0 180 $X=162530 $Y=127040
X702 1 2 227 1171 897 NO2I1JI3VX1 $T=184240 185920 0 0 $X=183810 $Y=185280
X703 1 2 897 337 227 NO2I1JI3VX1 $T=187600 185920 0 0 $X=187170 $Y=185280
X704 1 2 1172 1173 1174 NO2I1JI3VX1 $T=187600 203840 1 0 $X=187170 $Y=198720
X705 1 2 513 1175 515 NO2I1JI3VX1 $T=197680 176960 1 0 $X=197250 $Y=171840
X706 1 2 340 1176 231 NO2I1JI3VX1 $T=202720 168000 0 180 $X=198930 $Y=162880
X707 1 2 1177 1178 1179 NO2I1JI3VX1 $T=210000 159040 0 180 $X=206210 $Y=153920
X708 1 2 961 1180 515 NO2I1JI3VX1 $T=219520 194880 1 180 $X=215730 $Y=194240
X709 1 2 515 451 961 NO2I1JI3VX1 $T=235200 194880 1 180 $X=231410 $Y=194240
X710 1 2 361 315 362 NO2I1JI3VX1 $T=249760 168000 1 0 $X=249330 $Y=162880
X711 1 2 528 521 529 NO2I1JI3VX1 $T=278320 176960 0 180 $X=274530 $Y=171840
X712 1 2 125 524 527 NO2I1JI3VX1 $T=280560 168000 1 180 $X=276770 $Y=167360
X713 1 2 1136 99 1181 NO2I1JI3VX1 $T=306880 123200 0 0 $X=306450 $Y=122560
X714 1 2 260 1182 1037 NO2I1JI3VX1 $T=332640 168000 0 180 $X=328850 $Y=162880
X715 1 2 1047 1183 536 NO2I1JI3VX1 $T=337120 176960 0 180 $X=333330 $Y=171840
X716 1 2 536 378 1047 NO2I1JI3VX1 $T=338800 168000 1 180 $X=335010 $Y=167360
X717 1 2 269 1103 1184 271 784 AO22JI3VX1 $T=31360 168000 1 180 $X=25890 $Y=167360
X718 1 2 86 269 84 230 789 AO22JI3VX1 $T=44240 185920 1 180 $X=38770 $Y=185280
X719 1 2 89 269 464 230 798 AO22JI3VX1 $T=50960 185920 1 180 $X=45490 $Y=185280
X720 1 2 816 1185 1186 818 426 AO22JI3VX1 $T=86800 42560 0 180 $X=81330 $Y=37440
X721 1 2 833 1185 1186 803 431 AO22JI3VX1 $T=89040 33600 0 180 $X=83570 $Y=28480
X722 1 2 819 1185 1186 804 425 AO22JI3VX1 $T=95200 33600 0 180 $X=89730 $Y=28480
X723 1 2 831 1185 1186 832 432 AO22JI3VX1 $T=103040 33600 0 0 $X=102610 $Y=32960
X724 1 2 842 1185 1186 839 436 AO22JI3VX1 $T=109760 33600 0 0 $X=109330 $Y=32960
X725 1 2 854 1185 1186 840 424 AO22JI3VX1 $T=112000 33600 1 0 $X=111570 $Y=28480
X726 1 2 178 1187 1188 180 853 AO22JI3VX1 $T=130480 203840 1 180 $X=125010 $Y=203200
X727 1 2 858 1185 1186 861 435 AO22JI3VX1 $T=126560 24640 0 0 $X=126130 $Y=24000
X728 1 2 170 1187 1188 171 865 AO22JI3VX1 $T=131600 141120 1 180 $X=126130 $Y=140480
X729 1 2 166 1187 1188 167 866 AO22JI3VX1 $T=132160 159040 0 180 $X=126690 $Y=153920
X730 1 2 174 1187 1188 176 867 AO22JI3VX1 $T=132160 185920 0 180 $X=126690 $Y=180800
X731 1 2 183 1187 1188 184 857 AO22JI3VX1 $T=133840 194880 1 180 $X=128370 $Y=194240
X732 1 2 161 1187 1188 163 868 AO22JI3VX1 $T=129360 168000 1 0 $X=128930 $Y=162880
X733 1 2 1145 1187 1188 849 848 AO22JI3VX1 $T=137760 212800 1 0 $X=137330 $Y=207680
X734 1 2 193 156 1189 195 879 AO22JI3VX1 $T=146160 168000 1 180 $X=140690 $Y=167360
X735 1 2 196 156 1189 198 893 AO22JI3VX1 $T=141680 185920 1 0 $X=141250 $Y=180800
X736 1 2 203 156 1189 204 880 AO22JI3VX1 $T=146720 194880 1 180 $X=141250 $Y=194240
X737 1 2 871 1185 1186 872 422 AO22JI3VX1 $T=142240 33600 0 0 $X=141810 $Y=32960
X738 1 2 199 156 1189 201 881 AO22JI3VX1 $T=143360 212800 1 0 $X=142930 $Y=207680
X739 1 2 190 156 1189 192 877 AO22JI3VX1 $T=150640 159040 1 180 $X=145170 $Y=158400
X740 1 2 870 1185 1186 875 423 AO22JI3VX1 $T=148960 24640 0 0 $X=148530 $Y=24000
X741 1 2 186 156 1189 188 891 AO22JI3VX1 $T=150640 159040 0 0 $X=150210 $Y=158400
X742 1 2 1187 210 1188 211 894 AO22JI3VX1 $T=155120 141120 1 0 $X=154690 $Y=136000
X743 1 2 890 1185 1186 888 421 AO22JI3VX1 $T=156240 33600 0 0 $X=155810 $Y=32960
X744 1 2 156 214 1189 207 892 AO22JI3VX1 $T=163520 159040 1 180 $X=158050 $Y=158400
X745 1 2 1187 220 1188 221 900 AO22JI3VX1 $T=165760 141120 0 180 $X=160290 $Y=136000
X746 1 2 1146 156 1189 473 899 AO22JI3VX1 $T=160720 212800 1 0 $X=160290 $Y=207680
X747 1 2 907 1185 1186 887 433 AO22JI3VX1 $T=163520 33600 1 0 $X=163090 $Y=28480
X748 1 2 156 224 1189 217 912 AO22JI3VX1 $T=166880 159040 0 0 $X=166450 $Y=158400
X749 1 2 1147 1187 1188 507 895 AO22JI3VX1 $T=174160 176960 1 180 $X=168690 $Y=176320
X750 1 2 1152 1187 1188 897 896 AO22JI3VX1 $T=174160 185920 1 180 $X=168690 $Y=185280
X751 1 2 1190 1187 1188 509 898 AO22JI3VX1 $T=174160 194880 0 180 $X=168690 $Y=189760
X752 1 2 1149 156 1189 904 903 AO22JI3VX1 $T=174160 212800 0 180 $X=168690 $Y=207680
X753 1 2 908 1185 1186 910 438 AO22JI3VX1 $T=170240 24640 0 0 $X=169810 $Y=24000
X754 1 2 156 1191 1189 914 913 AO22JI3VX1 $T=181440 159040 1 180 $X=175970 $Y=158400
X755 1 2 1187 1192 1188 916 915 AO22JI3VX1 $T=180320 141120 1 0 $X=179890 $Y=136000
X756 1 2 1154 156 1189 920 919 AO22JI3VX1 $T=187040 212800 0 180 $X=181570 $Y=207680
X757 1 2 921 1185 1186 922 437 AO22JI3VX1 $T=187040 33600 0 0 $X=186610 $Y=32960
X758 1 2 1193 156 1189 511 934 AO22JI3VX1 $T=201040 203840 0 0 $X=200610 $Y=203200
X759 1 2 940 1185 1186 939 439 AO22JI3VX1 $T=205520 42560 1 0 $X=205090 $Y=37440
X760 1 2 1156 309 1194 982 981 AO22JI3VX1 $T=260960 194880 0 180 $X=255490 $Y=189760
X761 1 2 1195 1196 1115 1197 1198 AO22JI3VX1 $T=259840 176960 0 0 $X=259410 $Y=176320
X762 1 2 1159 309 1194 995 994 AO22JI3VX1 $T=262640 194880 0 0 $X=262210 $Y=194240
X763 1 2 986 1199 237 987 782 AO22JI3VX1 $T=266560 33600 1 0 $X=266130 $Y=28480
X764 1 2 1200 309 1194 1007 1006 AO22JI3VX1 $T=270480 194880 0 0 $X=270050 $Y=194240
X765 1 2 1014 1199 237 1012 1201 AO22JI3VX1 $T=299040 33600 1 0 $X=298610 $Y=28480
X766 1 2 1162 1139 1141 101 1030 AO22JI3VX1 $T=314720 194880 0 180 $X=309250 $Y=189760
X767 1 2 1202 1139 1141 532 1025 AO22JI3VX1 $T=320880 176960 1 180 $X=315410 $Y=176320
X768 1 2 1023 1199 237 1022 1203 AO22JI3VX1 $T=320320 33600 0 0 $X=319890 $Y=32960
X769 1 2 1021 1199 237 1026 1204 AO22JI3VX1 $T=320880 33600 1 0 $X=320450 $Y=28480
X770 1 2 1044 1205 1139 1120 1043 AO22JI3VX1 $T=341600 194880 0 180 $X=336130 $Y=189760
X771 1 2 1165 1139 1141 1057 1056 AO22JI3VX1 $T=352240 185920 1 180 $X=346770 $Y=185280
X772 1 2 1143 pulse_active BUJI3VX6 $T=55440 24640 0 0 $X=55010 $Y=24000
X773 1 2 140 110 BUJI3VX6 $T=77280 123200 0 0 $X=76850 $Y=122560
X774 1 2 1206 964 BUJI3VX6 $T=285600 132160 0 0 $X=285170 $Y=131520
X775 1 2 1071 237 BUJI3VX6 $T=373520 150080 1 0 $X=373090 $Y=144960
X776 1 2 461 1101 240 788 1207 ON31JI3VX1 $T=32480 150080 1 180 $X=27570 $Y=149440
X777 1 2 787 497 273 786 1208 ON31JI3VX1 $T=36960 176960 1 180 $X=32050 $Y=176320
X778 1 2 465 283 273 811 500 ON31JI3VX1 $T=63840 194880 0 180 $X=58930 $Y=189760
X779 1 2 928 1209 299 927 1210 ON31JI3VX1 $T=180320 168000 0 0 $X=179890 $Y=167360
X780 1 2 346 1211 351 946 1212 ON31JI3VX1 $T=211120 203840 0 0 $X=210690 $Y=203200
X781 1 2 485 1213 317 970 520 ON31JI3VX1 $T=249760 194880 1 180 $X=244850 $Y=194240
X782 1 2 529 1214 317 1010 1215 ON31JI3VX1 $T=274400 194880 1 0 $X=273970 $Y=189760
X783 1 2 1163 102 1182 1216 533 ON31JI3VX1 $T=328720 168000 1 180 $X=323810 $Y=167360
X784 1 2 536 534 389 1042 1217 ON31JI3VX1 $T=331520 185920 1 0 $X=331090 $Y=180800
X785 1 2 1055 1218 389 1054 1219 ON31JI3VX1 $T=347200 194880 1 0 $X=346770 $Y=189760
X786 1 2 265 1220 409 1081 1221 ON31JI3VX1 $T=392000 123200 1 0 $X=391570 $Y=118080
X787 1 2 134 104 397 133 1222 ON31JI3VX1 $T=394800 168000 1 0 $X=394370 $Y=162880
X788 1 2 878 916 223 1192 EO3JI3VX1 $T=167440 141120 0 0 $X=167010 $Y=140480
X789 1 2 878 914 225 1191 EO3JI3VX1 $T=169680 150080 1 0 $X=169250 $Y=144960
X790 1 2 114 783 BUJI3VX2 $T=124880 194880 1 0 $X=124450 $Y=189760
X791 1 2 458 145 BUJI3VX2 $T=192640 212800 0 0 $X=192210 $Y=212160
X792 1 2 237 1186 BUJI3VX2 $T=216160 33600 0 0 $X=215730 $Y=32960
X793 1 2 476 114 BUJI3VX2 $T=220640 185920 1 0 $X=220210 $Y=180800
X794 1 2 1199 1185 BUJI3VX2 $T=241920 33600 1 180 $X=238130 $Y=32960
X795 1 2 150 117 BUJI3VX2 $T=268800 212800 1 180 $X=265010 $Y=212160
X796 1 2 146 1206 BUJI3VX2 $T=282240 132160 0 0 $X=281810 $Y=131520
X797 1 2 1223 1224 BUJI3VX2 $T=305760 203840 0 0 $X=305330 $Y=203200
X798 1 2 1225 up_switches<16> BUJI3VX2 $T=328160 24640 1 0 $X=327730 $Y=19520
X799 1 2 367 up_switches<17> BUJI3VX2 $T=332080 24640 1 0 $X=331650 $Y=19520
X800 1 2 373 up_switches<18> BUJI3VX2 $T=335440 24640 1 0 $X=335010 $Y=19520
X801 1 2 376 up_switches<19> BUJI3VX2 $T=342720 24640 1 0 $X=342290 $Y=19520
X802 1 2 1201 up_switches<21> BUJI3VX2 $T=352240 24640 1 180 $X=348450 $Y=24000
X803 1 2 782 up_switches<20> BUJI3VX2 $T=362880 24640 0 180 $X=359090 $Y=19520
X804 1 2 1203 up_switches<23> BUJI3VX2 $T=360640 33600 1 0 $X=360210 $Y=28480
X805 1 2 386 up_switches<26> BUJI3VX2 $T=362880 24640 1 0 $X=362450 $Y=19520
X806 1 2 383 up_switches<25> BUJI3VX2 $T=366800 24640 0 0 $X=366370 $Y=24000
X807 1 2 1204 up_switches<24> BUJI3VX2 $T=366800 33600 1 0 $X=366370 $Y=28480
X808 1 2 392 up_switches<27> BUJI3VX2 $T=370160 24640 0 0 $X=369730 $Y=24000
X809 1 2 964 128 BUJI3VX2 $T=372960 51520 0 0 $X=372530 $Y=50880
X810 1 2 395 up_switches<28> BUJI3VX2 $T=381360 24640 1 0 $X=380930 $Y=19520
X811 1 2 1226 up_switches<29> BUJI3VX2 $T=397600 24640 0 180 $X=393810 $Y=19520
X812 1 2 1227 up_switches<30> BUJI3VX2 $T=402640 24640 0 180 $X=398850 $Y=19520
X813 1 2 1228 up_switches<31> BUJI3VX2 $T=402640 24640 1 0 $X=402210 $Y=19520
X814 1 2 230 enable INJI3VX3 $T=92960 176960 0 0 $X=92530 $Y=176320
X815 1 2 1094 838 INJI3VX3 $T=181440 159040 0 0 $X=181010 $Y=158400
X816 1 2 1185 1229 INJI3VX3 $T=194880 33600 1 0 $X=194450 $Y=28480
X817 1 2 1230 488 INJI3VX3 $T=215600 212800 0 0 $X=215170 $Y=212160
X818 1 2 1095 942 INJI3VX3 $T=233520 159040 1 180 $X=230290 $Y=158400
X819 1 2 1231 up_switches<14> INJI3VX3 $T=303520 24640 1 0 $X=303090 $Y=19520
X820 1 2 1232 up_switches<15> INJI3VX3 $T=308560 24640 1 0 $X=308130 $Y=19520
X821 1 2 1233 up_switches<22> INJI3VX3 $T=325920 24640 0 0 $X=325490 $Y=24000
X822 1 2 1234 230 160 342 NA3I2JI3VX1 $T=216160 168000 1 180 $X=211810 $Y=167360
X823 1 2 1180 451 1235 1236 NA3I2JI3VX1 $T=220640 194880 0 180 $X=216290 $Y=189760
X824 1 2 255 494 90 1138 NA3I2JI3VX1 $T=311920 212800 1 180 $X=307570 $Y=212160
X825 1 2 1122 1183 533 1237 NA3I2JI3VX1 $T=334880 168000 1 180 $X=330530 $Y=167360
X826 1 2 932 914 219 1238 EN3JI3VX1 $T=183120 123200 1 180 $X=172050 $Y=122560
X827 1 2 1239 807 783 1240 144 807 SDFRRQJI3VX1 $T=62160 78400 1 180 $X=41570 $Y=77760
X828 1 2 98 805 783 1241 144 805 SDFRRQJI3VX1 $T=62160 96320 0 180 $X=41570 $Y=91200
X829 1 2 1242 790 783 1243 144 790 SDFRRQJI3VX1 $T=62160 96320 1 180 $X=41570 $Y=95680
X830 1 2 1239 817 783 1244 144 817 SDFRRQJI3VX1 $T=62720 69440 1 180 $X=42130 $Y=68800
X831 1 2 98 806 783 1244 144 806 SDFRRQJI3VX1 $T=62720 78400 0 180 $X=42130 $Y=73280
X832 1 2 98 808 783 1240 144 808 SDFRRQJI3VX1 $T=62720 87360 0 180 $X=42130 $Y=82240
X833 1 2 1242 791 783 1245 144 791 SDFRRQJI3VX1 $T=62720 105280 0 180 $X=42130 $Y=100160
X834 1 2 1242 792 783 1246 144 792 SDFRRQJI3VX1 $T=62720 105280 1 180 $X=42130 $Y=104640
X835 1 2 1242 795 783 1247 144 795 SDFRRQJI3VX1 $T=63280 114240 0 180 $X=42690 $Y=109120
X836 1 2 1242 800 783 1248 144 800 SDFRRQJI3VX1 $T=77280 123200 1 180 $X=56690 $Y=122560
X837 1 2 1242 799 783 1249 144 799 SDFRRQJI3VX1 $T=80080 123200 0 180 $X=59490 $Y=118080
X838 1 2 1242 812 783 1244 144 812 SDFRRQJI3VX1 $T=80080 132160 0 180 $X=59490 $Y=127040
X839 1 2 1239 821 802 1248 144 821 SDFRRQJI3VX1 $T=64960 78400 0 0 $X=64530 $Y=77760
X840 1 2 98 820 783 1248 144 820 SDFRRQJI3VX1 $T=64960 87360 1 0 $X=64530 $Y=82240
X841 1 2 1239 830 783 1241 144 830 SDFRRQJI3VX1 $T=64960 87360 0 0 $X=64530 $Y=86720
X842 1 2 144 1246 783 1245 110 1246 SDFRRQJI3VX1 $T=65520 96320 1 0 $X=65090 $Y=91200
X843 1 2 144 1245 783 1248 110 1245 SDFRRQJI3VX1 $T=65520 96320 0 0 $X=65090 $Y=95680
X844 1 2 144 1248 783 1244 110 1248 SDFRRQJI3VX1 $T=65520 105280 0 0 $X=65090 $Y=104640
X845 1 2 144 1244 783 1240 110 1244 SDFRRQJI3VX1 $T=66080 105280 1 0 $X=65650 $Y=100160
X846 1 2 144 1240 783 1241 110 1240 SDFRRQJI3VX1 $T=67760 114240 0 0 $X=67330 $Y=113600
X847 1 2 1242 827 783 1241 144 827 SDFRRQJI3VX1 $T=70560 159040 1 0 $X=70130 $Y=153920
X848 1 2 1242 822 783 1240 144 822 SDFRRQJI3VX1 $T=71120 150080 0 0 $X=70690 $Y=149440
X849 1 2 98 841 802 1245 144 841 SDFRRQJI3VX1 $T=95200 69440 0 180 $X=74610 $Y=64320
X850 1 2 1239 844 802 1245 144 844 SDFRRQJI3VX1 $T=95200 69440 1 180 $X=74610 $Y=68800
X851 1 2 1239 834 802 1246 144 834 SDFRRQJI3VX1 $T=95200 78400 0 180 $X=74610 $Y=73280
X852 1 2 1250 1248 783 845 144 845 SDFRRQJI3VX1 $T=95200 114240 0 180 $X=74610 $Y=109120
X853 1 2 1242 824 783 1251 144 824 SDFRRQJI3VX1 $T=95200 132160 1 180 $X=74610 $Y=131520
X854 1 2 1250 1244 783 852 144 852 SDFRRQJI3VX1 $T=95200 159040 1 180 $X=74610 $Y=158400
X855 1 2 144 1243 783 1246 110 1243 SDFRRQJI3VX1 $T=103040 69440 1 0 $X=102610 $Y=64320
X856 1 2 98 843 802 1246 144 843 SDFRRQJI3VX1 $T=103040 78400 1 0 $X=102610 $Y=73280
X857 1 2 1250 1245 802 850 144 850 SDFRRQJI3VX1 $T=103040 105280 1 0 $X=102610 $Y=100160
X858 1 2 144 1241 783 1252 110 1241 SDFRRQJI3VX1 $T=103040 123200 0 0 $X=102610 $Y=122560
X859 1 2 1250 1246 802 851 144 851 SDFRRQJI3VX1 $T=103040 132160 1 0 $X=102610 $Y=127040
X860 1 2 1242 835 802 1253 144 835 SDFRRQJI3VX1 $T=103040 141120 0 0 $X=102610 $Y=140480
X861 1 2 1242 846 783 1252 144 846 SDFRRQJI3VX1 $T=103040 159040 1 0 $X=102610 $Y=153920
X862 1 2 1250 1240 429 836 SPI_CS 836 SDFRRQJI3VX1 $T=103040 185920 1 0 $X=102610 $Y=180800
X863 1 2 1250 1241 783 847 SPI_CS 847 SDFRRQJI3VX1 $T=103040 185920 0 0 $X=102610 $Y=185280
X864 1 2 1250 1243 802 864 144 864 SDFRRQJI3VX1 $T=110320 105280 0 0 $X=109890 $Y=104640
X865 1 2 1239 855 838 1243 144 855 SDFRRQJI3VX1 $T=110880 69440 0 0 $X=110450 $Y=68800
X866 1 2 1239 856 838 1247 144 856 SDFRRQJI3VX1 $T=110880 87360 1 0 $X=110450 $Y=82240
X867 1 2 98 859 838 1247 144 859 SDFRRQJI3VX1 $T=110880 87360 0 0 $X=110450 $Y=86720
X868 1 2 144 1251 838 1249 110 1251 SDFRRQJI3VX1 $T=110880 96320 1 0 $X=110450 $Y=91200
X869 1 2 98 860 802 1243 144 860 SDFRRQJI3VX1 $T=111440 78400 0 0 $X=111010 $Y=77760
X870 1 2 1250 1249 802 862 144 862 SDFRRQJI3VX1 $T=113680 114240 1 0 $X=113250 $Y=109120
X871 1 2 1250 1252 429 826 SPI_CS 826 SDFRRQJI3VX1 $T=115360 212800 0 0 $X=114930 $Y=212160
X872 1 2 144 1247 802 1243 110 1247 SDFRRQJI3VX1 $T=123200 96320 0 0 $X=122770 $Y=95680
X873 1 2 1250 1247 802 863 144 863 SDFRRQJI3VX1 $T=123200 123200 0 0 $X=122770 $Y=122560
X874 1 2 98 874 838 1249 144 874 SDFRRQJI3VX1 $T=131600 78400 1 0 $X=131170 $Y=73280
X875 1 2 1239 873 838 1249 144 873 SDFRRQJI3VX1 $T=131600 87360 1 0 $X=131170 $Y=82240
X876 1 2 144 1249 802 1247 110 1249 SDFRRQJI3VX1 $T=132160 105280 0 0 $X=131730 $Y=104640
X877 1 2 1239 883 838 1252 144 883 SDFRRQJI3VX1 $T=142240 96320 1 0 $X=141810 $Y=91200
X878 1 2 98 889 838 1251 144 889 SDFRRQJI3VX1 $T=142800 78400 0 0 $X=142370 $Y=77760
X879 1 2 98 886 838 1252 144 886 SDFRRQJI3VX1 $T=142800 87360 0 0 $X=142370 $Y=86720
X880 1 2 447 1188 114 1187 121 447 SDFRRQJI3VX1 $T=149520 176960 1 0 $X=149090 $Y=171840
X881 1 2 1150 1189 114 156 121 1150 SDFRRQJI3VX1 $T=152880 194880 0 0 $X=152450 $Y=194240
X882 1 2 1239 909 838 1253 144 909 SDFRRQJI3VX1 $T=162400 78400 1 0 $X=161970 $Y=73280
X883 1 2 1239 906 838 1251 144 906 SDFRRQJI3VX1 $T=162400 87360 1 0 $X=161970 $Y=82240
X884 1 2 98 911 838 1253 144 911 SDFRRQJI3VX1 $T=162960 69440 0 0 $X=162530 $Y=68800
X885 1 2 144 1253 838 1251 110 1253 SDFRRQJI3VX1 $T=165760 87360 0 0 $X=165330 $Y=86720
X886 1 2 1242 905 838 1254 144 905 SDFRRQJI3VX1 $T=186480 96320 0 180 $X=165890 $Y=91200
X887 1 2 1239 924 838 1254 144 924 SDFRRQJI3VX1 $T=178640 60480 0 0 $X=178210 $Y=59840
X888 1 2 98 923 838 1254 144 923 SDFRRQJI3VX1 $T=179760 69440 1 0 $X=179330 $Y=64320
X889 1 2 1239 937 429 1255 144 937 SDFRRQJI3VX1 $T=183120 78400 1 0 $X=182690 $Y=73280
X890 1 2 98 945 429 1256 144 945 SDFRRQJI3VX1 $T=203280 78400 1 180 $X=182690 $Y=77760
X891 1 2 144 1255 114 1254 110 1255 SDFRRQJI3VX1 $T=183120 96320 0 0 $X=182690 $Y=95680
X892 1 2 144 1254 114 1253 110 1254 SDFRRQJI3VX1 $T=187040 87360 1 0 $X=186610 $Y=82240
X893 1 2 98 941 429 1255 143 941 SDFRRQJI3VX1 $T=188160 69440 0 0 $X=187730 $Y=68800
X894 1 2 1250 1254 429 947 SPI_CS 947 SDFRRQJI3VX1 $T=212240 141120 0 180 $X=191650 $Y=136000
X895 1 2 1250 1251 429 935 SPI_CS 935 SDFRRQJI3VX1 $T=193200 141120 0 0 $X=192770 $Y=140480
X896 1 2 1250 1253 429 936 SPI_CS 936 SDFRRQJI3VX1 $T=193200 159040 0 0 $X=192770 $Y=158400
X897 1 2 1239 955 429 1257 143 955 SDFRRQJI3VX1 $T=223440 78400 0 180 $X=202850 $Y=73280
X898 1 2 1239 956 429 1256 143 956 SDFRRQJI3VX1 $T=223440 78400 1 180 $X=202850 $Y=77760
X899 1 2 1242 929 429 1256 143 929 SDFRRQJI3VX1 $T=223440 87360 1 180 $X=202850 $Y=86720
X900 1 2 143 1257 114 1256 110 1257 SDFRRQJI3VX1 $T=223440 96320 0 180 $X=202850 $Y=91200
X901 1 2 143 1256 114 1255 110 1256 SDFRRQJI3VX1 $T=223440 96320 1 180 $X=202850 $Y=95680
X902 1 2 1242 930 429 1255 143 930 SDFRRQJI3VX1 $T=223440 105280 0 180 $X=202850 $Y=100160
X903 1 2 1242 931 429 1257 143 931 SDFRRQJI3VX1 $T=223440 105280 1 180 $X=202850 $Y=104640
X904 1 2 1242 938 429 1258 143 938 SDFRRQJI3VX1 $T=223440 114240 0 180 $X=202850 $Y=109120
X905 1 2 1242 933 429 1259 143 933 SDFRRQJI3VX1 $T=223440 123200 1 180 $X=202850 $Y=122560
X906 1 2 1250 1255 429 966 143 966 SDFRRQJI3VX1 $T=223440 132160 0 180 $X=202850 $Y=127040
X907 1 2 1242 948 429 1260 143 948 SDFRRQJI3VX1 $T=223440 132160 1 180 $X=202850 $Y=131520
X908 1 2 98 954 942 1257 143 954 SDFRRQJI3VX1 $T=231840 69440 0 0 $X=231410 $Y=68800
X909 1 2 143 1252 123 1168 110 1252 SDFRRQJI3VX1 $T=231840 212800 0 0 $X=231410 $Y=212160
X910 1 2 1239 973 942 1259 143 973 SDFRRQJI3VX1 $T=232960 78400 0 0 $X=232530 $Y=77760
X911 1 2 98 975 942 1258 143 975 SDFRRQJI3VX1 $T=232960 87360 1 0 $X=232530 $Y=82240
X912 1 2 98 976 942 1259 143 976 SDFRRQJI3VX1 $T=232960 87360 0 0 $X=232530 $Y=86720
X913 1 2 143 1258 942 1257 110 1258 SDFRRQJI3VX1 $T=232960 96320 0 0 $X=232530 $Y=95680
X914 1 2 1250 1256 964 965 143 965 SDFRRQJI3VX1 $T=232960 105280 0 0 $X=232530 $Y=104640
X915 1 2 143 1259 964 1258 110 1259 SDFRRQJI3VX1 $T=233520 105280 1 0 $X=233090 $Y=100160
X916 1 2 1250 1257 964 968 143 968 SDFRRQJI3VX1 $T=237440 114240 0 0 $X=237010 $Y=113600
X917 1 2 1250 1259 964 992 143 992 SDFRRQJI3VX1 $T=239680 123200 1 0 $X=239250 $Y=118080
X918 1 2 98 998 942 1261 143 998 SDFRRQJI3VX1 $T=267680 78400 0 180 $X=247090 $Y=73280
X919 1 2 1242 949 429 1261 SPI_CS 949 SDFRRQJI3VX1 $T=271040 141120 0 180 $X=250450 $Y=136000
X920 1 2 1242 950 123 1262 SPI_CS 950 SDFRRQJI3VX1 $T=271040 141120 1 180 $X=250450 $Y=140480
X921 1 2 1242 983 964 1263 SPI_CS 983 SDFRRQJI3VX1 $T=272160 132160 1 180 $X=251570 $Y=131520
X922 1 2 1239 984 942 1258 143 984 SDFRRQJI3VX1 $T=254800 87360 1 0 $X=254370 $Y=82240
X923 1 2 98 989 942 1260 143 989 SDFRRQJI3VX1 $T=254800 87360 0 0 $X=254370 $Y=86720
X924 1 2 1239 988 942 1260 143 988 SDFRRQJI3VX1 $T=255360 96320 1 0 $X=254930 $Y=91200
X925 1 2 1250 1258 964 991 143 991 SDFRRQJI3VX1 $T=255920 114240 1 0 $X=255490 $Y=109120
X926 1 2 143 1261 942 1259 110 1261 SDFRRQJI3VX1 $T=256480 105280 1 0 $X=256050 $Y=100160
X927 1 2 1239 1002 942 1261 143 1002 SDFRRQJI3VX1 $T=271600 78400 1 0 $X=271170 $Y=73280
X928 1 2 143 1262 942 1261 110 1262 SDFRRQJI3VX1 $T=274400 96320 0 0 $X=273970 $Y=95680
X929 1 2 1239 1003 942 1262 143 1003 SDFRRQJI3VX1 $T=274960 78400 0 0 $X=274530 $Y=77760
X930 1 2 98 1004 942 1262 SPI_CS 1004 SDFRRQJI3VX1 $T=274960 87360 1 0 $X=274530 $Y=82240
X931 1 2 143 1260 942 1262 110 1260 SDFRRQJI3VX1 $T=295120 87360 1 180 $X=274530 $Y=86720
X932 1 2 1250 1260 964 1005 SPI_CS 1005 SDFRRQJI3VX1 $T=274960 132160 1 0 $X=274530 $Y=127040
X933 1 2 1250 1261 964 1009 SPI_CS 1009 SDFRRQJI3VX1 $T=274960 141120 1 0 $X=274530 $Y=136000
X934 1 2 1250 1262 964 1008 SPI_CS 1008 SDFRRQJI3VX1 $T=274960 141120 0 0 $X=274530 $Y=140480
X935 1 2 1242 997 964 1264 SPI_CS 997 SDFRRQJI3VX1 $T=295120 150080 0 180 $X=274530 $Y=144960
X936 1 2 143 1265 123 1266 110 1265 SDFRRQJI3VX1 $T=275520 212800 1 0 $X=275090 $Y=207680
X937 1 2 143 1264 942 1263 110 1264 SDFRRQJI3VX1 $T=278880 105280 0 0 $X=278450 $Y=104640
X938 1 2 143 1263 942 1260 110 1263 SDFRRQJI3VX1 $T=278880 114240 1 0 $X=278450 $Y=109120
X939 1 2 143 1266 123 1223 110 1266 SDFRRQJI3VX1 $T=299040 203840 1 180 $X=278450 $Y=203200
X940 1 2 100 1141 123 1139 121 100 SDFRRQJI3VX1 $T=310800 185920 0 180 $X=290210 $Y=180800
X941 1 2 143 1267 964 97 110 1267 SDFRRQJI3VX1 $T=291760 168000 0 0 $X=291330 $Y=167360
X942 1 2 143 490 964 1267 110 489 SDFRRQJI3VX1 $T=291760 185920 0 0 $X=291330 $Y=185280
X943 1 2 143 1224 964 491 110 1223 SDFRRQJI3VX1 $T=312480 203840 0 180 $X=291890 $Y=198720
X944 1 2 1239 1016 942 1263 143 1016 SDFRRQJI3VX1 $T=292880 105280 1 0 $X=292450 $Y=100160
X945 1 2 143 492 964 489 110 491 SDFRRQJI3VX1 $T=292880 194880 0 0 $X=292450 $Y=194240
X946 1 2 143 97 964 1181 110 97 SDFRRQJI3VX1 $T=314160 114240 1 180 $X=293570 $Y=113600
X947 1 2 98 1015 942 1263 143 1015 SDFRRQJI3VX1 $T=294560 96320 1 0 $X=294130 $Y=91200
X948 1 2 98 1017 942 1264 143 1017 SDFRRQJI3VX1 $T=295120 87360 1 0 $X=294690 $Y=82240
X949 1 2 1239 1019 942 1264 143 1019 SDFRRQJI3VX1 $T=295120 87360 0 0 $X=294690 $Y=86720
X950 1 2 143 1268 942 1264 110 1268 SDFRRQJI3VX1 $T=295120 123200 1 0 $X=294690 $Y=118080
X951 1 2 1250 1268 964 1033 SPI_CS 1033 SDFRRQJI3VX1 $T=298480 132160 1 0 $X=298050 $Y=127040
X952 1 2 1250 1263 964 1035 SPI_CS 1035 SDFRRQJI3VX1 $T=298480 141120 1 0 $X=298050 $Y=136000
X953 1 2 1242 1011 964 1268 SPI_CS 1011 SDFRRQJI3VX1 $T=318640 141120 1 180 $X=298050 $Y=140480
X954 1 2 1250 1264 964 1036 SPI_CS 1036 SDFRRQJI3VX1 $T=298480 150080 1 0 $X=298050 $Y=144960
X955 1 2 143 1181 964 1269 110 1181 SDFRRQJI3VX1 $T=333760 114240 0 180 $X=313170 $Y=109120
X956 1 2 1239 1028 964 1268 SPI_CS 1028 SDFRRQJI3VX1 $T=314720 96320 0 0 $X=314290 $Y=95680
X957 1 2 143 1270 964 1268 110 1270 SDFRRQJI3VX1 $T=314720 105280 1 0 $X=314290 $Y=100160
X958 1 2 98 1029 964 1268 SPI_CS 1029 SDFRRQJI3VX1 $T=315840 96320 1 0 $X=315410 $Y=91200
X959 1 2 1242 1034 964 1270 SPI_CS 1034 SDFRRQJI3VX1 $T=316960 114240 0 0 $X=316530 $Y=113600
X960 1 2 1239 1027 964 1270 SPI_CS 1027 SDFRRQJI3VX1 $T=338240 87360 0 180 $X=317650 $Y=82240
X961 1 2 98 1024 964 1270 SPI_CS 1024 SDFRRQJI3VX1 $T=338800 78400 1 180 $X=318210 $Y=77760
X962 1 2 98 1041 964 1271 SPI_CS 1041 SDFRRQJI3VX1 $T=351680 69440 1 180 $X=331090 $Y=68800
X963 1 2 1239 1040 964 1271 SPI_CS 1040 SDFRRQJI3VX1 $T=351680 78400 0 180 $X=331090 $Y=73280
X964 1 2 143 1271 964 1270 110 1271 SDFRRQJI3VX1 $T=352240 87360 1 180 $X=331650 $Y=86720
X965 1 2 1242 1048 964 1272 SPI_CS 1048 SDFRRQJI3VX1 $T=352240 105280 1 180 $X=331650 $Y=104640
X966 1 2 1242 1032 964 1271 SPI_CS 1032 SDFRRQJI3VX1 $T=352240 123200 0 180 $X=331650 $Y=118080
X967 1 2 1242 1046 964 1273 SPI_CS 1046 SDFRRQJI3VX1 $T=352240 123200 1 180 $X=331650 $Y=122560
X968 1 2 1239 1065 128 1273 SPI_CS 1065 SDFRRQJI3VX1 $T=360080 69440 0 0 $X=359650 $Y=68800
X969 1 2 98 1067 128 1273 SPI_CS 1067 SDFRRQJI3VX1 $T=360080 78400 1 0 $X=359650 $Y=73280
X970 1 2 1239 1053 128 1272 SPI_CS 1053 SDFRRQJI3VX1 $T=360080 78400 0 0 $X=359650 $Y=77760
X971 1 2 98 1051 128 1272 SPI_CS 1051 SDFRRQJI3VX1 $T=360080 87360 1 0 $X=359650 $Y=82240
X972 1 2 143 1272 128 1271 110 1272 SDFRRQJI3VX1 $T=360080 87360 0 0 $X=359650 $Y=86720
X973 1 2 143 1274 128 1273 110 1274 SDFRRQJI3VX1 $T=360080 96320 1 0 $X=359650 $Y=91200
X974 1 2 143 1273 128 1272 110 1273 SDFRRQJI3VX1 $T=360080 96320 0 0 $X=359650 $Y=95680
X975 1 2 1242 1058 128 1275 SPI_CS 1058 SDFRRQJI3VX1 $T=360080 114240 0 0 $X=359650 $Y=113600
X976 1 2 1242 1059 128 1274 SPI_CS 1059 SDFRRQJI3VX1 $T=360080 123200 1 0 $X=359650 $Y=118080
X977 1 2 1242 1060 128 1276 SPI_CS 1060 SDFRRQJI3VX1 $T=360080 123200 0 0 $X=359650 $Y=122560
X978 1 2 1242 1069 128 1269 SPI_CS 1069 SDFRRQJI3VX1 $T=360080 132160 1 0 $X=359650 $Y=127040
X979 1 2 143 1275 128 1274 110 1275 SDFRRQJI3VX1 $T=361200 105280 1 0 $X=360770 $Y=100160
X980 1 2 143 1276 128 1275 110 1276 SDFRRQJI3VX1 $T=381360 105280 1 180 $X=360770 $Y=104640
X981 1 2 143 1269 128 1276 110 1269 SDFRRQJI3VX1 $T=381360 114240 0 180 $X=360770 $Y=109120
X982 1 2 98 1078 128 1269 SPI_CS 1078 SDFRRQJI3VX1 $T=380240 78400 0 0 $X=379810 $Y=77760
X983 1 2 1239 1077 128 1269 SPI_CS 1077 SDFRRQJI3VX1 $T=380240 87360 1 0 $X=379810 $Y=82240
X984 1 2 1239 1076 128 1274 SPI_CS 1076 SDFRRQJI3VX1 $T=380240 87360 0 0 $X=379810 $Y=86720
X985 1 2 98 1079 128 1274 SPI_CS 1079 SDFRRQJI3VX1 $T=380240 96320 0 0 $X=379810 $Y=95680
X986 1 2 1277 1278 128 1124 122 1124 SDFRRQJI3VX1 $T=391440 132160 0 0 $X=391010 $Y=131520
X987 1 2 1239 1088 128 1276 SPI_CS 1088 SDFRRQJI3VX1 $T=395360 78400 1 0 $X=394930 $Y=73280
X988 1 2 1239 1086 128 1275 SPI_CS 1086 SDFRRQJI3VX1 $T=395360 96320 1 0 $X=394930 $Y=91200
X989 1 2 98 1087 128 1276 SPI_CS 1087 SDFRRQJI3VX1 $T=400400 87360 1 0 $X=399970 $Y=82240
X990 1 2 98 1089 128 1275 SPI_CS 1089 SDFRRQJI3VX1 $T=400400 87360 0 0 $X=399970 $Y=86720
X991 1 2 497 270 1105 NO2JI3VX0 $T=40880 168000 1 180 $X=38210 $Y=167360
X992 1 2 1102 1279 796 NO2JI3VX0 $T=44800 159040 0 0 $X=44370 $Y=158400
X993 1 2 1101 1170 797 NO2JI3VX0 $T=47040 159040 1 0 $X=46610 $Y=153920
X994 1 2 441 1280 440 NO2JI3VX0 $T=53200 168000 1 180 $X=50530 $Y=167360
X995 1 2 1107 1281 801 NO2JI3VX0 $T=52640 176960 0 0 $X=52210 $Y=176320
X996 1 2 1280 254 1281 NO2JI3VX0 $T=53760 168000 1 0 $X=53330 $Y=162880
X997 1 2 283 1282 1093 NO2JI3VX0 $T=62720 185920 0 180 $X=60050 $Y=180800
X998 1 2 1091 252 814 NO2JI3VX0 $T=62160 159040 1 0 $X=61730 $Y=153920
X999 1 2 281 244 825 NO2JI3VX0 $T=69440 185920 0 180 $X=66770 $Y=180800
X1000 1 2 281 1283 285 NO2JI3VX0 $T=71680 203840 0 180 $X=69010 $Y=198720
X1001 1 2 273 1284 282 NO2JI3VX0 $T=77840 194880 1 0 $X=77410 $Y=189760
X1002 1 2 1284 328 230 NO2JI3VX0 $T=80640 185920 1 180 $X=77970 $Y=185280
X1003 1 2 1285 1286 469 NO2JI3VX0 $T=148960 123200 1 0 $X=148530 $Y=118080
X1004 1 2 447 331 507 NO2JI3VX0 $T=179200 176960 1 180 $X=176530 $Y=176320
X1005 1 2 1287 1174 330 NO2JI3VX0 $T=179760 203840 1 0 $X=179330 $Y=198720
X1006 1 2 1288 338 1171 NO2JI3VX0 $T=184800 185920 1 0 $X=184370 $Y=180800
X1007 1 2 928 1127 349 NO2JI3VX0 $T=204960 185920 1 180 $X=202290 $Y=185280
X1008 1 2 159 517 158 NO2JI3VX0 $T=218960 176960 0 180 $X=216290 $Y=171840
X1009 1 2 518 343 157 NO2JI3VX0 $T=220080 185920 0 180 $X=217410 $Y=180800
X1010 1 2 311 359 963 NO2JI3VX0 $T=239680 168000 1 0 $X=239250 $Y=162880
X1011 1 2 1289 354 1194 NO2JI3VX0 $T=240240 194880 0 0 $X=239810 $Y=194240
X1012 1 2 317 1289 482 NO2JI3VX0 $T=244720 194880 1 180 $X=242050 $Y=194240
X1013 1 2 357 1290 311 NO2JI3VX0 $T=245280 176960 0 180 $X=242610 $Y=171840
X1014 1 2 1096 362 979 NO2JI3VX0 $T=253120 176960 1 180 $X=250450 $Y=176320
X1015 1 2 1213 1291 1096 NO2JI3VX0 $T=253120 185920 0 180 $X=250450 $Y=180800
X1016 1 2 1113 1292 969 NO2JI3VX0 $T=255360 168000 0 0 $X=254930 $Y=167360
X1017 1 2 1293 1195 985 NO2JI3VX0 $T=261520 185920 0 180 $X=258850 $Y=180800
X1018 1 2 367 1294 1225 NO2JI3VX0 $T=324800 24640 1 0 $X=324370 $Y=19520
X1019 1 2 1237 1131 259 NO2JI3VX0 $T=330960 168000 1 180 $X=328290 $Y=167360
X1020 1 2 453 258 452 NO2JI3VX0 $T=337680 159040 1 0 $X=337250 $Y=153920
X1021 1 2 376 1295 373 NO2JI3VX0 $T=338800 24640 0 0 $X=338370 $Y=24000
X1022 1 2 1164 1045 257 NO2JI3VX0 $T=339360 212800 0 0 $X=338930 $Y=212160
X1023 1 2 535 1166 453 NO2JI3VX0 $T=343840 176960 1 180 $X=341170 $Y=176320
X1024 1 2 127 257 496 NO2JI3VX0 $T=349440 212800 1 180 $X=346770 $Y=212160
X1025 1 2 1296 1297 1061 NO2JI3VX0 $T=352240 159040 1 180 $X=349570 $Y=158400
X1026 1 2 1226 1298 395 NO2JI3VX0 $T=380240 24640 0 180 $X=377570 $Y=19520
X1027 1 2 1125 405 265 NO2JI3VX0 $T=384720 114240 0 0 $X=384290 $Y=113600
X1028 1 2 1299 107 1049 NO2JI3VX0 $T=384720 141120 0 0 $X=384290 $Y=140480
X1029 1 2 1300 399 238 NO2JI3VX0 $T=385280 159040 1 0 $X=384850 $Y=153920
X1030 1 2 1301 1125 1124 NO2JI3VX0 $T=392000 105280 1 180 $X=389330 $Y=104640
X1031 1 2 1228 1302 1227 NO2JI3VX0 $T=393680 24640 0 180 $X=391010 $Y=19520
X1032 1 2 1303 275 1169 246 1304 NA4JI3VX0 $T=54320 159040 1 180 $X=49970 $Y=158400
X1033 1 2 1305 1177 512 514 448 NA4JI3VX0 $T=198240 185920 1 0 $X=197810 $Y=180800
X1034 1 2 1302 96 1295 1294 1298 NA4JI3VX0 $T=347760 24640 1 0 $X=347330 $Y=19520
X1035 1 2 106 1306 402 1307 404 NA4JI3VX0 $T=394240 141120 0 180 $X=389890 $Y=136000
X1036 1 2 787 1308 271 NA2JI3VX0 $T=26320 168000 1 0 $X=25890 $Y=162880
X1037 1 2 243 1207 320 NA2JI3VX0 $T=33600 150080 0 0 $X=33170 $Y=149440
X1038 1 2 787 1208 1184 NA2JI3VX0 $T=42000 176960 1 180 $X=39330 $Y=176320
X1039 1 2 794 1309 1092 NA2JI3VX0 $T=40880 159040 0 0 $X=40450 $Y=158400
X1040 1 2 241 462 322 NA2JI3VX0 $T=42000 150080 0 0 $X=41570 $Y=149440
X1041 1 2 797 1169 1101 NA2JI3VX0 $T=49840 150080 1 180 $X=47170 $Y=149440
X1042 1 2 796 246 1102 NA2JI3VX0 $T=47600 159040 0 0 $X=47170 $Y=158400
X1043 1 2 810 88 1282 NA2JI3VX0 $T=52080 185920 1 0 $X=51650 $Y=180800
X1044 1 2 1281 1310 442 NA2JI3VX0 $T=53760 176960 1 0 $X=53330 $Y=171840
X1045 1 2 814 253 1091 NA2JI3VX0 $T=67760 159040 0 180 $X=65090 $Y=153920
X1046 1 2 823 410 1109 NA2JI3VX0 $T=71120 168000 1 180 $X=68450 $Y=167360
X1047 1 2 833 1311 1186 NA2JI3VX0 $T=90160 24640 1 180 $X=87490 $Y=24000
X1048 1 2 816 1312 1186 NA2JI3VX0 $T=91280 42560 0 180 $X=88610 $Y=37440
X1049 1 2 831 1313 1186 NA2JI3VX0 $T=92400 42560 1 0 $X=91970 $Y=37440
X1050 1 2 819 1314 1186 NA2JI3VX0 $T=103600 24640 0 0 $X=103170 $Y=24000
X1051 1 2 842 1315 1186 NA2JI3VX0 $T=110320 24640 1 180 $X=107650 $Y=24000
X1052 1 2 854 1316 1186 NA2JI3VX0 $T=115360 24640 1 180 $X=112690 $Y=24000
X1053 1 2 858 1317 1186 NA2JI3VX0 $T=124880 33600 1 0 $X=124450 $Y=28480
X1054 1 2 871 1318 1186 NA2JI3VX0 $T=135520 33600 1 180 $X=132850 $Y=32960
X1055 1 2 876 286 1319 NA2JI3VX0 $T=133280 114240 0 0 $X=132850 $Y=113600
X1056 1 2 869 290 1319 NA2JI3VX0 $T=143920 114240 0 0 $X=143490 $Y=113600
X1057 1 2 870 1320 1186 NA2JI3VX0 $T=147840 24640 1 180 $X=145170 $Y=24000
X1058 1 2 468 293 1132 NA2JI3VX0 $T=148400 114240 1 180 $X=145730 $Y=113600
X1059 1 2 470 289 1132 NA2JI3VX0 $T=148960 123200 0 180 $X=146290 $Y=118080
X1060 1 2 890 1321 1186 NA2JI3VX0 $T=148960 33600 0 0 $X=148530 $Y=32960
X1061 1 2 885 1322 1319 NA2JI3VX0 $T=148960 114240 1 0 $X=148530 $Y=109120
X1062 1 2 882 294 1319 NA2JI3VX0 $T=152320 105280 0 0 $X=151890 $Y=104640
X1063 1 2 907 1323 1186 NA2JI3VX0 $T=160720 33600 0 180 $X=158050 $Y=28480
X1064 1 2 475 297 1132 NA2JI3VX0 $T=161840 114240 0 180 $X=159170 $Y=109120
X1065 1 2 902 1324 1319 NA2JI3VX0 $T=164640 114240 1 0 $X=164210 $Y=109120
X1066 1 2 908 1325 1186 NA2JI3VX0 $T=170240 33600 1 0 $X=169810 $Y=28480
X1067 1 2 918 1326 1319 NA2JI3VX0 $T=175840 123200 1 0 $X=175410 $Y=118080
X1068 1 2 509 1209 1153 NA2JI3VX0 $T=183680 194880 0 180 $X=181010 $Y=189760
X1069 1 2 921 1327 1186 NA2JI3VX0 $T=182560 33600 0 0 $X=182130 $Y=32960
X1070 1 2 928 1210 1328 NA2JI3VX0 $T=183120 176960 1 0 $X=182690 $Y=171840
X1071 1 2 513 336 1328 NA2JI3VX0 $T=189280 176960 0 180 $X=186610 $Y=171840
X1072 1 2 333 1172 1329 NA2JI3VX0 $T=189840 194880 1 180 $X=187170 $Y=194240
X1073 1 2 300 298 344 NA2JI3VX0 $T=195440 176960 1 0 $X=195010 $Y=171840
X1074 1 2 349 304 928 NA2JI3VX0 $T=202160 185920 1 180 $X=199490 $Y=185280
X1075 1 2 940 1330 1186 NA2JI3VX0 $T=203280 42560 1 180 $X=200610 $Y=41920
X1076 1 2 511 1211 1155 NA2JI3VX0 $T=206080 203840 0 0 $X=205650 $Y=203200
X1077 1 2 951 1331 1186 NA2JI3VX0 $T=211120 33600 1 180 $X=208450 $Y=32960
X1078 1 2 154 1332 229 NA2JI3VX0 $T=211120 185920 0 180 $X=208450 $Y=180800
X1079 1 2 reset_l 1230 479 NA2JI3VX0 $T=211680 212800 0 0 $X=211250 $Y=212160
X1080 1 2 346 1212 1333 NA2JI3VX0 $T=212800 203840 1 0 $X=212370 $Y=198720
X1081 1 2 952 1334 237 NA2JI3VX0 $T=213920 33600 0 0 $X=213490 $Y=32960
X1082 1 2 157 229 517 NA2JI3VX0 $T=216720 176960 0 180 $X=214050 $Y=171840
X1083 1 2 154 1179 343 NA2JI3VX0 $T=220080 159040 1 0 $X=219650 $Y=153920
X1084 1 2 972 1335 237 NA2JI3VX0 $T=235760 33600 0 180 $X=233090 $Y=28480
X1085 1 2 961 353 1333 NA2JI3VX0 $T=237440 203840 0 180 $X=234770 $Y=198720
X1086 1 2 974 1336 237 NA2JI3VX0 $T=244160 33600 0 180 $X=241490 $Y=28480
X1087 1 2 233 361 232 NA2JI3VX0 $T=248080 168000 1 180 $X=245410 $Y=167360
X1088 1 2 959 1213 1290 NA2JI3VX0 $T=248640 185920 0 180 $X=245970 $Y=180800
X1089 1 2 967 368 237 NA2JI3VX0 $T=253120 33600 0 0 $X=252690 $Y=32960
X1090 1 2 972 366 151 NA2JI3VX0 $T=257040 42560 1 0 $X=256610 $Y=37440
X1091 1 2 986 1337 237 NA2JI3VX0 $T=261520 33600 1 0 $X=261090 $Y=28480
X1092 1 2 993 1197 1114 NA2JI3VX0 $T=269920 185920 1 180 $X=267250 $Y=185280
X1093 1 2 1007 1214 1160 NA2JI3VX0 $T=268800 194880 1 0 $X=268370 $Y=189760
X1094 1 2 369 319 318 NA2JI3VX0 $T=270480 176960 0 0 $X=270050 $Y=176320
X1095 1 2 990 374 237 NA2JI3VX0 $T=272160 42560 1 0 $X=271730 $Y=37440
X1096 1 2 125 371 1338 NA2JI3VX0 $T=277760 185920 0 180 $X=275090 $Y=180800
X1097 1 2 529 1215 1338 NA2JI3VX0 $T=275520 185920 0 0 $X=275090 $Y=185280
X1098 1 2 1001 1339 237 NA2JI3VX0 $T=278320 33600 0 180 $X=275650 $Y=28480
X1099 1 2 1000 1340 237 NA2JI3VX0 $T=278320 42560 0 180 $X=275650 $Y=37440
X1100 1 2 999 377 237 NA2JI3VX0 $T=278320 24640 0 0 $X=277890 $Y=24000
X1101 1 2 154 345 249 NA2JI3VX0 $T=281120 168000 0 0 $X=280690 $Y=167360
X1102 1 2 1000 372 151 NA2JI3VX0 $T=282240 42560 1 0 $X=281810 $Y=37440
X1103 1 2 1001 375 151 NA2JI3VX0 $T=282800 33600 1 0 $X=282370 $Y=28480
X1104 1 2 1014 1341 237 NA2JI3VX0 $T=295680 24640 1 180 $X=293010 $Y=24000
X1105 1 2 1018 1342 237 NA2JI3VX0 $T=295680 33600 1 180 $X=293010 $Y=32960
X1106 1 2 154 1343 235 NA2JI3VX0 $T=297920 176960 1 0 $X=297490 $Y=171840
X1107 1 2 1181 1344 1136 NA2JI3VX0 $T=302960 123200 0 0 $X=302530 $Y=122560
X1108 1 2 1023 1345 237 NA2JI3VX0 $T=313040 33600 1 180 $X=310370 $Y=32960
X1109 1 2 494 91 411 NA2JI3VX0 $T=313040 212800 0 0 $X=312610 $Y=212160
X1110 1 2 1021 1346 237 NA2JI3VX0 $T=316960 33600 1 0 $X=316530 $Y=28480
X1111 1 2 103 260 1117 NA2JI3VX0 $T=321440 168000 1 0 $X=321010 $Y=162880
X1112 1 2 532 534 1163 NA2JI3VX0 $T=329840 176960 0 0 $X=329410 $Y=176320
X1113 1 2 536 1217 1205 NA2JI3VX0 $T=330960 194880 1 0 $X=330530 $Y=189760
X1114 1 2 1038 1347 237 NA2JI3VX0 $T=332080 33600 0 0 $X=331650 $Y=32960
X1115 1 2 1039 384 237 NA2JI3VX0 $T=337120 33600 1 0 $X=336690 $Y=28480
X1116 1 2 1038 382 151 NA2JI3VX0 $T=337120 42560 1 0 $X=336690 $Y=37440
X1117 1 2 1050 385 151 NA2JI3VX0 $T=343280 42560 1 0 $X=342850 $Y=37440
X1118 1 2 1050 1348 237 NA2JI3VX0 $T=345520 42560 1 0 $X=345090 $Y=37440
X1119 1 2 1052 387 237 NA2JI3VX0 $T=349440 51520 1 0 $X=349010 $Y=46400
X1120 1 2 1061 1349 1296 NA2JI3VX0 $T=351680 168000 0 180 $X=349010 $Y=162880
X1121 1 2 1068 1350 1121 NA2JI3VX0 $T=365680 176960 0 180 $X=363010 $Y=171840
X1122 1 2 1055 1219 1351 NA2JI3VX0 $T=363440 185920 1 0 $X=363010 $Y=180800
X1123 1 2 130 390 1351 NA2JI3VX0 $T=367920 185920 0 180 $X=365250 $Y=180800
X1124 1 2 1064 1352 237 NA2JI3VX0 $T=366240 42560 1 0 $X=365810 $Y=37440
X1125 1 2 1066 393 237 NA2JI3VX0 $T=370720 42560 0 180 $X=368050 $Y=37440
X1126 1 2 1064 391 151 NA2JI3VX0 $T=372960 42560 0 180 $X=370290 $Y=37440
X1127 1 2 1075 1353 237 NA2JI3VX0 $T=371840 33600 1 0 $X=371410 $Y=28480
X1128 1 2 1074 1354 237 NA2JI3VX0 $T=375200 42560 0 180 $X=372530 $Y=37440
X1129 1 2 1074 394 151 NA2JI3VX0 $T=376880 42560 1 0 $X=376450 $Y=37440
X1130 1 2 1072 396 237 NA2JI3VX0 $T=377440 33600 0 0 $X=377010 $Y=32960
X1131 1 2 132 398 400 NA2JI3VX0 $T=385840 159040 1 180 $X=383170 $Y=158400
X1132 1 2 265 1221 406 NA2JI3VX0 $T=385840 123200 1 0 $X=385410 $Y=118080
X1133 1 2 1355 1307 132 NA2JI3VX0 $T=389200 141120 0 180 $X=386530 $Y=136000
X1134 1 2 1085 1356 237 NA2JI3VX0 $T=396480 33600 0 180 $X=393810 $Y=28480
X1135 1 2 1084 1357 237 NA2JI3VX0 $T=396480 33600 1 180 $X=393810 $Y=32960
X1136 1 2 105 402 104 NA2JI3VX0 $T=395360 150080 1 0 $X=394930 $Y=144960
X1137 1 2 134 1222 408 NA2JI3VX0 $T=395920 159040 0 0 $X=395490 $Y=158400
X1138 1 2 267 1277 1306 NA2JI3VX0 $T=402080 141120 0 180 $X=399410 $Y=136000
X1139 1 2 1358 1229 1313 down_switches<4> ON21JI3VX4 $T=91280 42560 1 180 $X=82450 $Y=41920
X1140 1 2 1359 1229 1311 down_switches<1> ON21JI3VX4 $T=84560 24640 1 0 $X=84130 $Y=19520
X1141 1 2 1360 1229 1312 down_switches<2> ON21JI3VX4 $T=87360 33600 0 0 $X=86930 $Y=32960
X1142 1 2 1361 1229 1314 down_switches<3> ON21JI3VX4 $T=109760 24640 0 180 $X=100930 $Y=19520
X1143 1 2 1362 1229 1315 down_switches<5> ON21JI3VX4 $T=109760 24640 1 0 $X=109330 $Y=19520
X1144 1 2 1363 1229 1316 down_switches<6> ON21JI3VX4 $T=118160 24640 1 0 $X=117730 $Y=19520
X1145 1 2 1364 1229 1317 down_switches<7> ON21JI3VX4 $T=134960 24640 0 180 $X=126130 $Y=19520
X1146 1 2 1365 1229 1318 down_switches<9> ON21JI3VX4 $T=137200 33600 0 180 $X=128370 $Y=28480
X1147 1 2 1366 1229 1320 down_switches<8> ON21JI3VX4 $T=140000 24640 1 180 $X=131170 $Y=24000
X1148 1 2 1367 1229 1321 down_switches<0> ON21JI3VX4 $T=154560 33600 0 180 $X=145730 $Y=28480
X1149 1 2 1368 1229 1323 down_switches<10> ON21JI3VX4 $T=160720 24640 0 180 $X=151890 $Y=19520
X1150 1 2 1369 1229 1325 down_switches<11> ON21JI3VX4 $T=170240 24640 1 180 $X=161410 $Y=24000
X1151 1 2 1370 1229 1327 down_switches<12> ON21JI3VX4 $T=183120 33600 0 180 $X=174290 $Y=28480
X1152 1 2 1371 1229 1330 down_switches<13> ON21JI3VX4 $T=201600 42560 0 180 $X=192770 $Y=37440
X1153 1 2 1372 1229 1331 down_switches<14> ON21JI3VX4 $T=207760 33600 0 180 $X=198930 $Y=28480
X1154 1 2 1373 1229 1334 down_switches<15> ON21JI3VX4 $T=218960 33600 0 180 $X=210130 $Y=28480
X1155 1 2 1374 1229 1335 down_switches<17> ON21JI3VX4 $T=239120 24640 0 180 $X=230290 $Y=19520
X1156 1 2 1375 1229 1336 down_switches<16> ON21JI3VX4 $T=241360 24640 1 180 $X=232530 $Y=24000
X1157 1 2 1376 1229 1337 down_switches<20> ON21JI3VX4 $T=266560 24640 1 180 $X=257730 $Y=24000
X1158 1 2 1377 1229 1340 down_switches<18> ON21JI3VX4 $T=270480 42560 0 180 $X=261650 $Y=37440
X1159 1 2 1378 1229 1339 down_switches<19> ON21JI3VX4 $T=274960 33600 1 180 $X=266130 $Y=32960
X1160 1 2 1379 1229 1341 down_switches<21> ON21JI3VX4 $T=296240 24640 0 180 $X=287410 $Y=19520
X1161 1 2 1380 1229 1342 down_switches<22> ON21JI3VX4 $T=296240 33600 0 180 $X=287410 $Y=28480
X1162 1 2 1381 1229 1345 down_switches<23> ON21JI3VX4 $T=317520 24640 1 180 $X=308690 $Y=24000
X1163 1 2 1382 1229 1346 down_switches<24> ON21JI3VX4 $T=322000 24640 0 180 $X=313170 $Y=19520
X1164 1 2 1383 1229 1347 down_switches<25> ON21JI3VX4 $T=337120 24640 1 180 $X=328290 $Y=24000
X1165 1 2 1384 1229 1348 down_switches<26> ON21JI3VX4 $T=351120 33600 1 180 $X=342290 $Y=32960
X1166 1 2 1385 1229 1352 down_switches<27> ON21JI3VX4 $T=366240 33600 1 180 $X=357410 $Y=32960
X1167 1 2 1386 1229 1354 down_switches<28> ON21JI3VX4 $T=366240 42560 0 180 $X=357410 $Y=37440
X1168 1 2 1387 1229 1353 down_switches<31> ON21JI3VX4 $T=376880 24640 0 180 $X=368050 $Y=19520
X1169 1 2 1388 1229 1357 down_switches<30> ON21JI3VX4 $T=393680 33600 1 180 $X=384850 $Y=32960
X1170 1 2 1389 1229 1356 down_switches<29> ON21JI3VX4 $T=386960 24640 0 0 $X=386530 $Y=24000
X1171 1 2 1143 876 112 AND2JI3VX1 $T=61600 33600 1 0 $X=61170 $Y=28480
X1172 1 2 1143 869 1098 AND2JI3VX1 $T=62160 24640 0 0 $X=61730 $Y=24000
X1173 1 2 1143 902 113 AND2JI3VX1 $T=75600 33600 1 0 $X=75170 $Y=28480
X1174 1 2 1143 882 1099 AND2JI3VX1 $T=137760 33600 1 0 $X=137330 $Y=28480
X1175 1 2 1143 885 1100 AND2JI3VX1 $T=142240 24640 0 0 $X=141810 $Y=24000
X1176 1 2 1143 918 120 AND2JI3VX1 $T=180320 24640 1 180 $X=176530 $Y=24000
X1177 1 2 1144 1233 1231 1232 94 NA4JI3VX2 $T=306320 24640 1 180 $X=298610 $Y=24000
X1178 1 2 151 1199 237 NO2I1JI3VX2 $T=313040 33600 0 180 $X=307570 $Y=28480
X1179 1 2 1286 503 1390 EO2JI3VX0 $T=141680 123200 0 180 $X=135650 $Y=118080
X1180 1 2 505 1391 1392 EO2JI3VX0 $T=156240 132160 0 180 $X=150210 $Y=127040
X1181 1 2 509 1153 1190 EO2JI3VX0 $T=181440 194880 0 180 $X=175410 $Y=189760
X1182 1 2 511 1155 1193 EO2JI3VX0 $T=194320 203840 0 0 $X=193890 $Y=203200
X1183 1 2 1007 1160 1200 EO2JI3VX0 $T=271040 203840 1 0 $X=270610 $Y=198720
X1184 1 2 1265 IC_addr<1> 1135 EO2JI3VX0 $T=278880 212800 0 0 $X=278450 $Y=212160
X1185 1 2 1266 IC_addr<0> 1137 EO2JI3VX0 $T=286720 212800 0 0 $X=286290 $Y=212160
X1186 1 2 532 1163 1202 EO2JI3VX0 $T=328160 176960 0 180 $X=322130 $Y=171840
X1187 1 2 1105 793 443 AND2JI3VX0 $T=41440 168000 0 0 $X=41010 $Y=167360
X1188 1 2 278 253 1304 AND2JI3VX0 $T=61600 159040 0 180 $X=57810 $Y=153920
X1189 1 2 231 236 1393 AND2JI3VX0 $T=211680 168000 1 0 $X=211250 $Y=162880
X1190 1 2 1096 979 1134 AND2JI3VX0 $T=250320 176960 1 180 $X=246530 $Y=176320
X1191 1 2 1291 978 1157 AND2JI3VX0 $T=250880 194880 0 0 $X=250450 $Y=194240
X1192 1 2 151 974 1394 AND2JI3VX0 $T=255920 33600 0 180 $X=252130 $Y=28480
X1193 1 2 127 495 1164 AND2JI3VX0 $T=346640 212800 1 180 $X=342850 $Y=212160
X1194 1 2 151 1075 1395 AND2JI3VX0 $T=384160 33600 0 180 $X=380370 $Y=28480
X1195 1 2 403 1307 1300 AND2JI3VX0 $T=389200 150080 0 180 $X=385410 $Y=144960
X1196 1 2 151 1085 1396 AND2JI3VX0 $T=397040 33600 1 0 $X=396610 $Y=28480
X1197 1 2 151 1084 1397 AND2JI3VX0 $T=400400 33600 0 0 $X=399970 $Y=32960
X1198 1 2 1107 1282 1108 1093 810 AN22JI3VX1 $T=59360 185920 0 180 $X=55010 $Y=180800
X1199 1 2 282 1283 1110 281 285 AN22JI3VX1 $T=71680 194880 1 180 $X=67330 $Y=194240
X1200 1 2 825 281 247 1398 828 AN22JI3VX1 $T=74480 176960 1 180 $X=70130 $Y=176320
X1201 1 2 1390 1176 292 1178 167 AN22JI3VX1 $T=137200 114240 0 0 $X=136770 $Y=113600
X1202 1 2 1399 1176 288 1178 163 AN22JI3VX1 $T=142240 132160 0 180 $X=137890 $Y=127040
X1203 1 2 1392 1176 296 1178 171 AN22JI3VX1 $T=150080 132160 0 180 $X=145730 $Y=127040
X1204 1 2 926 1132 1400 1178 211 AN22JI3VX1 $T=154560 123200 1 0 $X=154130 $Y=118080
X1205 1 2 925 1132 1401 1178 221 AN22JI3VX1 $T=172480 132160 0 180 $X=168130 $Y=127040
X1206 1 2 932 1132 1402 1178 916 AN22JI3VX1 $T=184240 132160 0 180 $X=179890 $Y=127040
X1207 1 2 227 226 305 1287 330 AN22JI3VX1 $T=187040 203840 0 180 $X=182690 $Y=198720
X1208 1 2 951 1185 1231 1186 943 AN22JI3VX1 $T=223440 33600 1 180 $X=219090 $Y=32960
X1209 1 2 349 346 1235 1403 980 AN22JI3VX1 $T=223440 185920 1 180 $X=219090 $Y=185280
X1210 1 2 952 1185 1232 237 953 AN22JI3VX1 $T=240800 33600 0 180 $X=236450 $Y=28480
X1211 1 2 963 311 316 357 356 AN22JI3VX1 $T=238000 159040 0 0 $X=237570 $Y=158400
X1212 1 2 232 1290 1111 311 959 AN22JI3VX1 $T=241920 176960 0 0 $X=241490 $Y=176320
X1213 1 2 1113 1291 1112 978 1096 AN22JI3VX1 $T=254240 185920 1 180 $X=249890 $Y=185280
X1214 1 2 1018 1199 1233 237 1013 AN22JI3VX1 $T=297920 33600 0 0 $X=297490 $Y=32960
X1215 1 2 1404 1405 1406 1122 1350 AN22JI3VX1 $T=344960 168000 1 180 $X=340610 $Y=167360
X1216 1 2 1063 1407 1408 1097 1049 AN22JI3VX1 $T=380240 132160 0 0 $X=379810 $Y=131520
X1217 1 2 1063 1409 404 1299 1049 AN22JI3VX1 $T=383040 141120 1 0 $X=382610 $Y=136000
X1218 1 2 1410 1408 1301 136 1355 AN22JI3VX1 $T=389760 123200 1 180 $X=385410 $Y=122560
X1219 1 2 97 1344 1250 NO2JI3VX2 $T=301280 123200 1 180 $X=296370 $Y=122560
X1220 1 2 230 282 1284 829 AO21JI3VX1 $T=80640 194880 1 0 $X=80210 $Y=189760
X1221 1 2 469 1285 1286 1399 AO21JI3VX1 $T=146720 123200 0 180 $X=141810 $Y=118080
X1222 1 2 1411 507 1175 449 AO21JI3VX1 $T=186480 176960 0 0 $X=186050 $Y=176320
X1223 1 2 482 1194 1289 962 AO21JI3VX1 $T=240240 194880 1 180 $X=235330 $Y=194240
X1224 1 2 534 1139 1141 1205 AO21JI3VX1 $T=327040 185920 1 0 $X=326610 $Y=180800
X1225 1 2 1349 258 1297 1404 AO21JI3VX1 $T=348320 159040 1 180 $X=343410 $Y=158400
X1226 1 2 1218 1139 1141 1351 AO21JI3VX1 $T=345520 185920 1 0 $X=345090 $Y=180800
X1227 1 2 237 1300 238 1070 AO21JI3VX1 $T=375760 159040 1 0 $X=375330 $Y=153920
X1228 1 2 1344 1239 97 NA2I1JI3VX2 $T=300720 105280 0 0 $X=300290 $Y=104640
X1229 1 2 97 1242 99 NA2I1JI3VX2 $T=313040 123200 0 0 $X=312610 $Y=122560
X1230 1 2 497 269 enable 1184 NA22JI3VX1 $T=40880 176960 1 0 $X=40450 $Y=171840
X1231 1 2 1093 813 442 1412 NA22JI3VX1 $T=61040 176960 0 180 $X=56690 $Y=171840
X1232 1 2 1209 1187 298 1328 NA22JI3VX1 $T=179200 176960 1 0 $X=178770 $Y=171840
X1233 1 2 1211 156 153 1333 NA22JI3VX1 $T=204400 203840 1 0 $X=203970 $Y=198720
X1234 1 2 985 1293 1196 1413 NA22JI3VX1 $T=258720 176960 1 180 $X=254370 $Y=176320
X1235 1 2 1214 309 319 1338 NA22JI3VX1 $T=271040 185920 0 0 $X=270610 $Y=185280
X1236 1 2 1062 1123 1350 455 NA22JI3VX1 $T=348880 168000 0 0 $X=348450 $Y=167360
X1237 1 2 1301 152 267 1090 NA22JI3VX1 $T=394800 105280 0 0 $X=394370 $Y=104640
X1238 1 2 237 1394 971 1225 MU2JI3VX0 $T=250320 24640 0 0 $X=249890 $Y=24000
X1239 1 2 237 1395 1073 1228 MU2JI3VX0 $T=380240 24640 0 0 $X=379810 $Y=24000
X1240 1 2 237 1396 1082 1226 MU2JI3VX0 $T=402640 24640 1 180 $X=396610 $Y=24000
X1241 1 2 237 1397 1083 1227 MU2JI3VX0 $T=408240 33600 0 180 $X=402210 $Y=28480
X1242 1 2 779 425 426 1142 OR3JI3VX1 $T=188160 33600 1 0 $X=187730 $Y=28480
X1243 1 2 306 1236 1414 340 OR3JI3VX1 $T=202720 194880 1 0 $X=202290 $Y=189760
X1244 1 2 525 1195 1292 1415 OR3JI3VX1 $T=258720 168000 0 0 $X=258290 $Y=167360
X1245 1 2 1415 522 1115 1416 OR3JI3VX1 $T=263200 168000 0 180 $X=258850 $Y=162880
X1246 1 2 1201 1203 1204 93 OR3JI3VX1 $T=350000 33600 0 180 $X=345650 $Y=28480
X1247 1 2 1279 274 1170 1304 1169 ON211JI3VX1 $T=49840 159040 1 0 $X=49410 $Y=153920
X1248 1 2 443 1303 1417 326 1310 ON211JI3VX1 $T=54320 168000 0 0 $X=53890 $Y=167360
X1249 1 2 828 1133 1398 1418 410 ON211JI3VX1 $T=72800 176960 0 180 $X=68450 $Y=171840
X1250 1 2 205 884 1419 1322 1400 ON211JI3VX1 $T=154000 114240 1 0 $X=153570 $Y=109120
X1251 1 2 1419 901 216 1324 1401 ON211JI3VX1 $T=166880 114240 0 0 $X=166450 $Y=113600
X1252 1 2 1419 917 1238 1326 1402 ON211JI3VX1 $T=178080 123200 1 0 $X=177650 $Y=118080
X1253 1 2 333 1414 1329 1173 228 ON211JI3VX1 $T=190960 194880 0 0 $X=190530 $Y=194240
X1254 1 2 1172 1420 1174 305 307 ON211JI3VX1 $T=191520 203840 1 0 $X=191090 $Y=198720
X1255 1 2 1421 347 228 1420 308 ON211JI3VX1 $T=196000 194880 0 0 $X=195570 $Y=194240
X1256 1 2 1175 300 1126 343 514 ON211JI3VX1 $T=198800 176960 0 0 $X=198370 $Y=176320
X1257 1 2 1179 944 1177 342 1393 ON211JI3VX1 $T=207200 168000 1 0 $X=206770 $Y=162880
X1258 1 2 154 1422 516 1423 1424 ON211JI3VX1 $T=218960 159040 0 180 $X=214610 $Y=153920
X1259 1 2 230 957 1425 1423 1179 ON211JI3VX1 $T=220640 168000 0 180 $X=216290 $Y=162880
X1260 1 2 524 318 1129 160 526 ON211JI3VX1 $T=273280 176960 0 180 $X=268930 $Y=171840
X1261 1 2 1049 1410 1097 1220 105 ON211JI3VX1 $T=385840 132160 1 0 $X=385410 $Y=127040
X1262 1 2 1308 269 321 1184 AN21JI3VX1 $T=29680 168000 1 0 $X=29250 $Y=162880
X1263 1 2 1280 1309 1417 1106 AN21JI3VX1 $T=49840 168000 1 0 $X=49410 $Y=162880
X1264 1 2 801 1107 327 1412 AN21JI3VX1 $T=56560 176960 0 0 $X=56130 $Y=176320
X1265 1 2 283 269 499 230 AN21JI3VX1 $T=66640 185920 1 180 $X=62850 $Y=185280
X1266 1 2 1426 501 1391 502 AN21JI3VX1 $T=150080 123200 0 0 $X=149650 $Y=122560
X1267 1 2 506 1427 206 504 AN21JI3VX1 $T=154560 123200 0 0 $X=154130 $Y=122560
X1268 1 2 508 332 1288 1148 AN21JI3VX1 $T=180880 185920 1 0 $X=180450 $Y=180800
X1269 1 2 928 1428 334 513 AN21JI3VX1 $T=184800 168000 0 0 $X=184370 $Y=167360
X1270 1 2 333 1429 301 1127 AN21JI3VX1 $T=194320 194880 0 180 $X=190530 $Y=189760
X1271 1 2 1332 345 1189 155 AN21JI3VX1 $T=207200 185920 0 180 $X=203410 $Y=180800
X1272 1 2 346 347 450 1180 AN21JI3VX1 $T=210560 194880 0 0 $X=210130 $Y=194240
X1273 1 2 160 1234 1425 1430 AN21JI3VX1 $T=216160 168000 0 0 $X=215730 $Y=167360
X1274 1 2 346 1431 350 961 AN21JI3VX1 $T=222880 194880 1 180 $X=219090 $Y=194240
X1275 1 2 1213 309 519 1194 AN21JI3VX1 $T=245840 194880 0 180 $X=242050 $Y=189760
X1276 1 2 234 360 363 1134 AN21JI3VX1 $T=243040 168000 1 0 $X=242610 $Y=162880
X1277 1 2 969 1113 365 1413 AN21JI3VX1 $T=256480 176960 0 180 $X=252690 $Y=171840
X1278 1 2 996 1116 1196 1432 AN21JI3VX1 $T=263200 185920 1 180 $X=259410 $Y=185280
X1279 1 2 1292 1433 1128 1198 AN21JI3VX1 $T=260400 176960 1 0 $X=259970 $Y=171840
X1280 1 2 529 1434 370 125 AN21JI3VX1 $T=281680 185920 0 180 $X=277890 $Y=180800
X1281 1 2 1343 345 1141 1140 AN21JI3VX1 $T=302960 176960 1 0 $X=302530 $Y=171840
X1282 1 2 1406 380 1140 235 AN21JI3VX1 $T=312480 176960 0 180 $X=308690 $Y=171840
X1283 1 2 531 1216 379 1183 AN21JI3VX1 $T=322560 168000 1 180 $X=318770 $Y=167360
X1284 1 2 1037 1119 261 1297 AN21JI3VX1 $T=338240 159040 0 0 $X=337810 $Y=158400
X1285 1 2 1055 1167 388 130 AN21JI3VX1 $T=362880 176960 1 180 $X=359090 $Y=176320
X1286 1 2 237 1300 397 238 AN21JI3VX1 $T=380800 159040 1 0 $X=380370 $Y=153920
X1287 1 2 152 1301 409 1124 AN21JI3VX1 $T=394240 114240 1 0 $X=393810 $Y=109120
X1288 1 2 271 1102 INJI3VX0 $T=33600 168000 1 0 $X=33170 $Y=162880
X1289 1 2 242 1101 INJI3VX0 $T=38640 159040 0 180 $X=36530 $Y=153920
X1290 1 2 270 1104 INJI3VX0 $T=38640 168000 1 180 $X=36530 $Y=167360
X1291 1 2 787 1105 INJI3VX0 $T=38640 176960 1 0 $X=38210 $Y=171840
X1292 1 2 1309 444 INJI3VX0 $T=47040 168000 1 0 $X=46610 $Y=162880
X1293 1 2 810 1107 INJI3VX0 $T=52080 185920 0 0 $X=51650 $Y=185280
X1294 1 2 273 269 INJI3VX0 $T=56560 176960 1 180 $X=54450 $Y=176320
X1295 1 2 279 445 INJI3VX0 $T=63280 150080 1 180 $X=61170 $Y=149440
X1296 1 2 285 1109 INJI3VX0 $T=67200 194880 0 180 $X=65090 $Y=189760
X1297 1 2 1279 1418 INJI3VX0 $T=71680 159040 1 180 $X=69570 $Y=158400
X1298 1 2 282 1398 INJI3VX0 $T=70560 185920 1 0 $X=70130 $Y=180800
X1299 1 2 284 281 INJI3VX0 $T=75040 203840 0 180 $X=72930 $Y=198720
X1300 1 2 803 1359 INJI3VX0 $T=83440 24640 0 0 $X=83010 $Y=24000
X1301 1 2 818 1360 INJI3VX0 $T=84000 33600 0 0 $X=83570 $Y=32960
X1302 1 2 804 1361 INJI3VX0 $T=94080 24640 1 180 $X=91970 $Y=24000
X1303 1 2 832 1358 INJI3VX0 $T=92960 42560 0 0 $X=92530 $Y=41920
X1304 1 2 839 1362 INJI3VX0 $T=108640 33600 0 180 $X=106530 $Y=28480
X1305 1 2 840 1363 INJI3VX0 $T=117040 24640 0 0 $X=116610 $Y=24000
X1306 1 2 861 1364 INJI3VX0 $T=123200 24640 0 0 $X=122770 $Y=24000
X1307 1 2 872 1365 INJI3VX0 $T=136640 33600 0 0 $X=136210 $Y=32960
X1308 1 2 195 1285 INJI3VX0 $T=139440 159040 0 0 $X=139010 $Y=158400
X1309 1 2 875 1366 INJI3VX0 $T=141680 24640 1 180 $X=139570 $Y=24000
X1310 1 2 1286 1426 INJI3VX0 $T=152880 123200 0 180 $X=150770 $Y=118080
X1311 1 2 888 1367 INJI3VX0 $T=154560 33600 1 180 $X=152450 $Y=32960
X1312 1 2 1391 1427 INJI3VX0 $T=152880 123200 1 0 $X=152450 $Y=118080
X1313 1 2 926 208 INJI3VX0 $T=164640 114240 1 180 $X=162530 $Y=113600
X1314 1 2 887 1368 INJI3VX0 $T=164640 24640 1 0 $X=164210 $Y=19520
X1315 1 2 910 1369 INJI3VX0 $T=168000 24640 1 0 $X=167570 $Y=19520
X1316 1 2 925 218 INJI3VX0 $T=170800 123200 1 180 $X=168690 $Y=122560
X1317 1 2 298 1188 INJI3VX0 $T=172480 176960 0 180 $X=170370 $Y=171840
X1318 1 2 1176 1419 INJI3VX0 $T=172480 114240 0 0 $X=172050 $Y=113600
X1319 1 2 299 1187 INJI3VX0 $T=175840 176960 0 180 $X=173730 $Y=171840
X1320 1 2 904 1287 INJI3VX0 $T=175840 203840 1 0 $X=175410 $Y=198720
X1321 1 2 1209 1428 INJI3VX0 $T=178080 168000 0 0 $X=177650 $Y=167360
X1322 1 2 1150 1329 INJI3VX0 $T=178640 194880 0 0 $X=178210 $Y=194240
X1323 1 2 922 1370 INJI3VX0 $T=183120 33600 1 0 $X=182690 $Y=28480
X1324 1 2 920 226 INJI3VX0 $T=183680 203840 0 0 $X=183250 $Y=203200
X1325 1 2 330 1411 INJI3VX0 $T=184240 176960 0 0 $X=183810 $Y=176320
X1326 1 2 333 446 INJI3VX0 $T=190960 176960 0 0 $X=190530 $Y=176320
X1327 1 2 447 1429 INJI3VX0 $T=192080 185920 1 0 $X=191650 $Y=180800
X1328 1 2 307 1421 INJI3VX0 $T=204400 203840 0 180 $X=202290 $Y=198720
X1329 1 2 1189 153 INJI3VX0 $T=203280 194880 0 0 $X=202850 $Y=194240
X1330 1 2 943 1372 INJI3VX0 $T=205520 33600 0 0 $X=205090 $Y=32960
X1331 1 2 939 1371 INJI3VX0 $T=208880 42560 1 180 $X=206770 $Y=41920
X1332 1 2 156 351 INJI3VX0 $T=208320 203840 0 0 $X=207890 $Y=203200
X1333 1 2 516 1430 INJI3VX0 $T=209440 176960 1 0 $X=209010 $Y=171840
X1334 1 2 1211 1431 INJI3VX0 $T=209440 203840 1 0 $X=209010 $Y=198720
X1335 1 2 1178 1424 INJI3VX0 $T=211120 159040 1 0 $X=210690 $Y=153920
X1336 1 2 1132 1423 INJI3VX0 $T=215040 168000 1 0 $X=214610 $Y=162880
X1337 1 2 346 1403 INJI3VX0 $T=215600 185920 0 0 $X=215170 $Y=185280
X1338 1 2 980 349 INJI3VX0 $T=219520 185920 1 180 $X=217410 $Y=185280
X1339 1 2 953 1373 INJI3VX0 $T=219520 33600 1 0 $X=219090 $Y=28480
X1340 1 2 967 1374 INJI3VX0 $T=233520 33600 0 180 $X=231410 $Y=28480
X1341 1 2 960 311 INJI3VX0 $T=241920 185920 0 0 $X=241490 $Y=185280
X1342 1 2 971 1375 INJI3VX0 $T=246960 24640 1 180 $X=244850 $Y=24000
X1343 1 2 959 232 INJI3VX0 $T=250320 185920 0 180 $X=248210 $Y=180800
X1344 1 2 978 1113 INJI3VX0 $T=257040 185920 1 180 $X=254930 $Y=185280
X1345 1 2 1413 1433 INJI3VX0 $T=257600 176960 1 0 $X=257170 $Y=171840
X1346 1 2 982 1293 INJI3VX0 $T=262640 194880 0 180 $X=260530 $Y=189760
X1347 1 2 317 309 INJI3VX0 $T=264320 194880 0 180 $X=262210 $Y=189760
X1348 1 2 1197 1432 INJI3VX0 $T=265440 185920 0 180 $X=263330 $Y=180800
X1349 1 2 995 1116 INJI3VX0 $T=266000 194880 0 180 $X=263890 $Y=189760
X1350 1 2 1007 1114 INJI3VX0 $T=267680 194880 0 180 $X=265570 $Y=189760
X1351 1 2 987 1376 INJI3VX0 $T=269360 24640 1 180 $X=267250 $Y=24000
X1352 1 2 319 1194 INJI3VX0 $T=273280 194880 0 180 $X=271170 $Y=189760
X1353 1 2 990 1377 INJI3VX0 $T=272160 42560 0 0 $X=271730 $Y=41920
X1354 1 2 999 1378 INJI3VX0 $T=276640 33600 0 0 $X=276210 $Y=32960
X1355 1 2 1214 1434 INJI3VX0 $T=278880 185920 0 0 $X=278450 $Y=185280
X1356 1 2 1013 1380 INJI3VX0 $T=295120 42560 0 0 $X=294690 $Y=41920
X1357 1 2 249 1020 INJI3VX0 $T=297360 168000 1 0 $X=296930 $Y=162880
X1358 1 2 1012 1379 INJI3VX0 $T=300720 24640 0 180 $X=298610 $Y=19520
X1359 1 2 1022 1381 INJI3VX0 $T=315280 33600 0 0 $X=314850 $Y=32960
X1360 1 2 100 1119 INJI3VX0 $T=319760 159040 0 0 $X=319330 $Y=158400
X1361 1 2 101 1117 INJI3VX0 $T=321440 168000 0 180 $X=319330 $Y=162880
X1362 1 2 1026 1382 INJI3VX0 $T=323680 24640 1 180 $X=321570 $Y=24000
X1363 1 2 1039 1383 INJI3VX0 $T=333760 33600 1 0 $X=333330 $Y=28480
X1364 1 2 1044 453 INJI3VX0 $T=337680 176960 0 0 $X=337250 $Y=176320
X1365 1 2 455 1405 INJI3VX0 $T=340480 176960 1 0 $X=340050 $Y=171840
X1366 1 2 1167 1218 INJI3VX0 $T=344400 185920 0 0 $X=343970 $Y=185280
X1367 1 2 1139 389 INJI3VX0 $T=345520 194880 1 0 $X=345090 $Y=189760
X1368 1 2 1349 454 INJI3VX0 $T=347760 168000 0 180 $X=345650 $Y=162880
X1369 1 2 1052 1384 INJI3VX0 $T=346640 51520 1 0 $X=346210 $Y=46400
X1370 1 2 1057 1296 INJI3VX0 $T=347760 176960 1 0 $X=347330 $Y=171840
X1371 1 2 127 126 INJI3VX0 $T=348320 212800 1 0 $X=347890 $Y=207680
X1372 1 2 1055 1123 INJI3VX0 $T=362880 176960 0 180 $X=360770 $Y=171840
X1373 1 2 130 1121 INJI3VX0 $T=364560 176960 1 180 $X=362450 $Y=176320
X1374 1 2 1066 1385 INJI3VX0 $T=367920 33600 1 180 $X=365810 $Y=32960
X1375 1 2 1073 1387 INJI3VX0 $T=374640 24640 0 0 $X=374210 $Y=24000
X1376 1 2 1072 1386 INJI3VX0 $T=375200 42560 1 0 $X=374770 $Y=37440
X1377 1 2 132 1409 INJI3VX0 $T=381360 141120 0 180 $X=379250 $Y=136000
X1378 1 2 136 1407 INJI3VX0 $T=384160 123200 1 180 $X=382050 $Y=122560
X1379 1 2 1063 1355 INJI3VX0 $T=385840 132160 0 0 $X=385410 $Y=131520
X1380 1 2 138 1220 INJI3VX0 $T=389200 123200 1 0 $X=388770 $Y=118080
X1381 1 2 134 1299 INJI3VX0 $T=390880 150080 1 180 $X=388770 $Y=149440
X1382 1 2 1124 267 INJI3VX0 $T=392560 123200 0 0 $X=392130 $Y=122560
X1383 1 2 408 401 INJI3VX0 $T=394240 159040 1 180 $X=392130 $Y=158400
X1384 1 2 1082 1389 INJI3VX0 $T=397040 24640 1 180 $X=394930 $Y=24000
X1385 1 2 263 104 INJI3VX0 $T=395920 159040 1 0 $X=395490 $Y=153920
X1386 1 2 1306 1278 INJI3VX0 $T=398160 141120 0 180 $X=396050 $Y=136000
X1387 1 2 1083 1388 INJI3VX0 $T=405440 33600 1 180 $X=403330 $Y=32960
X1388 1 2 327 251 1106 277 NO3I1JI3VX1 $T=57120 168000 1 0 $X=56690 $Y=162880
X1389 1 2 508 1305 1171 302 NO3I1JI3VX1 $T=187040 185920 1 0 $X=186610 $Y=180800
X1390 1 2 342 1319 1176 1422 NO3I1JI3VX1 $T=206080 159040 0 180 $X=201170 $Y=153920
X1391 1 2 365 1234 314 1416 NO3I1JI3VX1 $T=254240 168000 1 0 $X=253810 $Y=162880
X1392 1 2 531 1130 378 1118 NO3I1JI3VX1 $T=319760 168000 0 180 $X=314850 $Y=162880
X1393 1 2 DECAP25JI3V $T=20160 24640 1 0 $X=19730 $Y=19520
X1394 1 2 DECAP25JI3V $T=20160 24640 0 0 $X=19730 $Y=24000
X1395 1 2 DECAP25JI3V $T=20160 33600 1 0 $X=19730 $Y=28480
X1396 1 2 DECAP25JI3V $T=20160 42560 1 0 $X=19730 $Y=37440
X1397 1 2 DECAP25JI3V $T=20160 42560 0 0 $X=19730 $Y=41920
X1398 1 2 DECAP25JI3V $T=20160 51520 1 0 $X=19730 $Y=46400
X1399 1 2 DECAP25JI3V $T=20160 51520 0 0 $X=19730 $Y=50880
X1400 1 2 DECAP25JI3V $T=20160 60480 1 0 $X=19730 $Y=55360
X1401 1 2 DECAP25JI3V $T=20160 60480 0 0 $X=19730 $Y=59840
X1402 1 2 DECAP25JI3V $T=20160 69440 1 0 $X=19730 $Y=64320
X1403 1 2 DECAP25JI3V $T=20160 69440 0 0 $X=19730 $Y=68800
X1404 1 2 DECAP25JI3V $T=20160 78400 1 0 $X=19730 $Y=73280
X1405 1 2 DECAP25JI3V $T=20160 78400 0 0 $X=19730 $Y=77760
X1406 1 2 DECAP25JI3V $T=20160 87360 1 0 $X=19730 $Y=82240
X1407 1 2 DECAP25JI3V $T=20160 87360 0 0 $X=19730 $Y=86720
X1408 1 2 DECAP25JI3V $T=20160 96320 1 0 $X=19730 $Y=91200
X1409 1 2 DECAP25JI3V $T=20160 141120 0 0 $X=19730 $Y=140480
X1410 1 2 DECAP25JI3V $T=20160 194880 0 0 $X=19730 $Y=194240
X1411 1 2 DECAP25JI3V $T=20160 203840 1 0 $X=19730 $Y=198720
X1412 1 2 DECAP25JI3V $T=20160 203840 0 0 $X=19730 $Y=203200
X1413 1 2 DECAP25JI3V $T=20160 212800 1 0 $X=19730 $Y=207680
X1414 1 2 DECAP25JI3V $T=20160 212800 0 0 $X=19730 $Y=212160
X1415 1 2 DECAP25JI3V $T=34160 33600 1 0 $X=33730 $Y=28480
X1416 1 2 DECAP25JI3V $T=34160 60480 0 0 $X=33730 $Y=59840
X1417 1 2 DECAP25JI3V $T=34160 87360 0 0 $X=33730 $Y=86720
X1418 1 2 DECAP25JI3V $T=34160 203840 1 0 $X=33730 $Y=198720
X1419 1 2 DECAP25JI3V $T=34160 212800 1 0 $X=33730 $Y=207680
X1420 1 2 DECAP25JI3V $T=34160 212800 0 0 $X=33730 $Y=212160
X1421 1 2 DECAP25JI3V $T=48160 87360 0 0 $X=47730 $Y=86720
X1422 1 2 DECAP25JI3V $T=48160 212800 0 0 $X=47730 $Y=212160
X1423 1 2 DECAP25JI3V $T=57120 132160 0 0 $X=56690 $Y=131520
X1424 1 2 DECAP25JI3V $T=80080 123200 1 0 $X=79650 $Y=118080
X1425 1 2 DECAP25JI3V $T=85680 96320 0 0 $X=85250 $Y=95680
X1426 1 2 DECAP25JI3V $T=86240 87360 0 0 $X=85810 $Y=86720
X1427 1 2 DECAP25JI3V $T=86240 105280 1 0 $X=85810 $Y=100160
X1428 1 2 DECAP25JI3V $T=89040 114240 0 0 $X=88610 $Y=113600
X1429 1 2 DECAP25JI3V $T=93520 105280 0 0 $X=93090 $Y=104640
X1430 1 2 DECAP25JI3V $T=110880 87360 0 180 $X=96450 $Y=82240
X1431 1 2 DECAP25JI3V $T=215040 114240 0 0 $X=214610 $Y=113600
X1432 1 2 DECAP25JI3V $T=223440 123200 0 0 $X=223010 $Y=122560
X1433 1 2 DECAP25JI3V $T=231840 96320 1 0 $X=231410 $Y=91200
X1434 1 2 DECAP25JI3V $T=257600 114240 0 0 $X=257170 $Y=113600
X1435 1 2 DECAP25JI3V $T=271600 114240 0 0 $X=271170 $Y=113600
X1436 1 2 DECAP25JI3V $T=295120 78400 0 0 $X=294690 $Y=77760
X1437 1 2 DECAP25JI3V $T=308000 132160 0 0 $X=307570 $Y=131520
X1438 1 2 DECAP25JI3V $T=312480 105280 0 0 $X=312050 $Y=104640
X1439 1 2 DECAP25JI3V $T=313040 194880 0 0 $X=312610 $Y=194240
X1440 1 2 DECAP25JI3V $T=318080 123200 0 0 $X=317650 $Y=122560
X1441 1 2 DECAP25JI3V $T=333760 114240 1 0 $X=333330 $Y=109120
X1442 1 2 DECAP25JI3V $T=336000 105280 1 0 $X=335570 $Y=100160
X1443 1 2 DECAP25JI3V $T=338240 87360 1 0 $X=337810 $Y=82240
X1444 1 2 DECAP25JI3V $T=350000 212800 1 0 $X=349570 $Y=207680
X1445 1 2 DECAP25JI3V $T=351120 203840 0 0 $X=350690 $Y=203200
X1446 1 2 DECAP25JI3V $T=352240 212800 0 0 $X=351810 $Y=212160
X1447 1 2 DECAP25JI3V $T=352800 203840 1 0 $X=352370 $Y=198720
X1448 1 2 DECAP25JI3V $T=364000 212800 1 0 $X=363570 $Y=207680
X1449 1 2 DECAP25JI3V $T=365120 203840 0 0 $X=364690 $Y=203200
X1450 1 2 DECAP25JI3V $T=366240 212800 0 0 $X=365810 $Y=212160
X1451 1 2 DECAP25JI3V $T=366800 203840 1 0 $X=366370 $Y=198720
X1452 1 2 DECAP25JI3V $T=370160 194880 1 0 $X=369730 $Y=189760
X1453 1 2 DECAP25JI3V $T=371280 194880 0 0 $X=370850 $Y=194240
X1454 1 2 DECAP25JI3V $T=378000 212800 1 0 $X=377570 $Y=207680
X1455 1 2 DECAP25JI3V $T=379120 185920 0 0 $X=378690 $Y=185280
X1456 1 2 DECAP25JI3V $T=379120 203840 0 0 $X=378690 $Y=203200
X1457 1 2 DECAP25JI3V $T=380240 212800 0 0 $X=379810 $Y=212160
X1458 1 2 DECAP25JI3V $T=380800 176960 0 0 $X=380370 $Y=176320
X1459 1 2 DECAP25JI3V $T=380800 203840 1 0 $X=380370 $Y=198720
X1460 1 2 DECAP25JI3V $T=381360 176960 1 0 $X=380930 $Y=171840
X1461 1 2 DECAP25JI3V $T=384160 194880 1 0 $X=383730 $Y=189760
X1462 1 2 DECAP25JI3V $T=385280 194880 0 0 $X=384850 $Y=194240
X1463 1 2 DECAP25JI3V $T=389200 185920 1 0 $X=388770 $Y=180800
X1464 1 2 DECAP25JI3V $T=392000 212800 1 0 $X=391570 $Y=207680
X1465 1 2 DECAP25JI3V $T=393120 185920 0 0 $X=392690 $Y=185280
X1466 1 2 DECAP25JI3V $T=393120 203840 0 0 $X=392690 $Y=203200
X1467 1 2 DECAP25JI3V $T=394240 212800 0 0 $X=393810 $Y=212160
X1468 1 2 DECAP25JI3V $T=394800 176960 0 0 $X=394370 $Y=176320
X1469 1 2 DECAP25JI3V $T=394800 203840 1 0 $X=394370 $Y=198720
X1470 1 2 DECAP25JI3V $T=395360 176960 1 0 $X=394930 $Y=171840
X1471 1 2 DECAP25JI3V $T=398160 194880 1 0 $X=397730 $Y=189760
X1472 1 2 DECAP25JI3V $T=398720 141120 0 0 $X=398290 $Y=140480
X1473 1 2 DECAP25JI3V $T=398720 150080 1 0 $X=398290 $Y=144960
X1474 1 2 DECAP25JI3V $T=399280 194880 0 0 $X=398850 $Y=194240
X1475 1 2 DECAP25JI3V $T=399840 159040 0 0 $X=399410 $Y=158400
X1476 1 2 DECAP25JI3V $T=400400 78400 0 0 $X=399970 $Y=77760
X1477 1 2 DECAP25JI3V $T=400400 96320 0 0 $X=399970 $Y=95680
X1478 1 2 DECAP25JI3V $T=414400 168000 0 180 $X=399970 $Y=162880
X1479 1 2 DECAP25JI3V $T=402080 141120 1 0 $X=401650 $Y=136000
X1480 1 2 DECAP25JI3V $T=403200 185920 1 0 $X=402770 $Y=180800
X1481 1 2 DECAP25JI3V $T=404320 159040 1 0 $X=403890 $Y=153920
X1482 1 2 DECAP25JI3V $T=406000 24640 1 0 $X=405570 $Y=19520
X1483 1 2 DECAP25JI3V $T=406000 212800 1 0 $X=405570 $Y=207680
X1484 1 2 DECAP25JI3V $T=406560 105280 0 0 $X=406130 $Y=104640
X1485 1 2 DECAP25JI3V $T=406560 114240 1 0 $X=406130 $Y=109120
X1486 1 2 DECAP25JI3V $T=407120 185920 0 0 $X=406690 $Y=185280
X1487 1 2 DECAP25JI3V $T=407120 203840 0 0 $X=406690 $Y=203200
X1488 1 2 DECAP25JI3V $T=407680 168000 0 0 $X=407250 $Y=167360
X1489 1 2 DECAP25JI3V $T=408800 150080 0 0 $X=408370 $Y=149440
X1490 1 2 DECAP25JI3V $T=408800 176960 0 0 $X=408370 $Y=176320
X1491 1 2 DECAP25JI3V $T=408800 203840 1 0 $X=408370 $Y=198720
X1492 1 2 DECAP25JI3V $T=409360 24640 0 0 $X=408930 $Y=24000
X1493 1 2 DECAP25JI3V $T=409360 176960 1 0 $X=408930 $Y=171840
X1494 1 2 DECAP25JI3V $T=409920 132160 1 0 $X=409490 $Y=127040
X1495 1 2 DECAP25JI3V $T=412720 132160 0 0 $X=412290 $Y=131520
X1496 1 2 DECAP25JI3V $T=412720 141120 0 0 $X=412290 $Y=140480
X1497 1 2 DECAP25JI3V $T=412720 150080 1 0 $X=412290 $Y=144960
X1498 1 2 DECAP25JI3V $T=413280 42560 1 0 $X=412850 $Y=37440
X1499 1 2 DECAP25JI3V $T=413280 60480 0 0 $X=412850 $Y=59840
X1500 1 2 DECAP25JI3V $T=413280 69440 1 0 $X=412850 $Y=64320
X1501 1 2 DECAP25JI3V $T=413280 69440 0 0 $X=412850 $Y=68800
X1502 1 2 DECAP25JI3V $T=413280 105280 1 0 $X=412850 $Y=100160
X1503 1 2 DECAP25JI3V $T=413280 194880 0 0 $X=412850 $Y=194240
X1504 1 2 DECAP25JI3V $T=414400 78400 0 0 $X=413970 $Y=77760
X1505 1 2 DECAP25JI3V $T=414400 96320 0 0 $X=413970 $Y=95680
X1506 1 2 DECAP25JI3V $T=414400 168000 1 0 $X=413970 $Y=162880
X1507 1 2 DECAP25JI3V $T=417200 185920 1 0 $X=416770 $Y=180800
X1508 1 2 DECAP25JI3V $T=418320 159040 1 0 $X=417890 $Y=153920
X1509 1 2 DECAP25JI3V $T=421120 185920 0 0 $X=420690 $Y=185280
X1510 1 2 DECAP25JI3V $T=421120 203840 0 0 $X=420690 $Y=203200
X1511 1 2 DECAP15JI3V $T=20160 33600 0 0 $X=19730 $Y=32960
X1512 1 2 DECAP15JI3V $T=20160 96320 0 0 $X=19730 $Y=95680
X1513 1 2 DECAP15JI3V $T=20160 141120 1 0 $X=19730 $Y=136000
X1514 1 2 DECAP15JI3V $T=34160 24640 1 0 $X=33730 $Y=19520
X1515 1 2 DECAP15JI3V $T=34160 60480 1 0 $X=33730 $Y=55360
X1516 1 2 DECAP15JI3V $T=34160 69440 0 0 $X=33730 $Y=68800
X1517 1 2 DECAP15JI3V $T=34160 78400 1 0 $X=33730 $Y=73280
X1518 1 2 DECAP15JI3V $T=34160 203840 0 0 $X=33730 $Y=203200
X1519 1 2 DECAP15JI3V $T=48160 60480 0 0 $X=47730 $Y=59840
X1520 1 2 DECAP15JI3V $T=48160 212800 1 0 $X=47730 $Y=207680
X1521 1 2 DECAP15JI3V $T=54880 114240 0 0 $X=54450 $Y=113600
X1522 1 2 DECAP15JI3V $T=61040 69440 1 0 $X=60610 $Y=64320
X1523 1 2 DECAP15JI3V $T=62720 69440 0 0 $X=62290 $Y=68800
X1524 1 2 DECAP15JI3V $T=62720 78400 1 0 $X=62290 $Y=73280
X1525 1 2 DECAP15JI3V $T=80080 132160 1 0 $X=79650 $Y=127040
X1526 1 2 DECAP15JI3V $T=84000 123200 0 0 $X=83570 $Y=122560
X1527 1 2 DECAP15JI3V $T=86800 96320 1 0 $X=86370 $Y=91200
X1528 1 2 DECAP15JI3V $T=90160 185920 1 0 $X=89730 $Y=180800
X1529 1 2 DECAP15JI3V $T=90160 212800 1 0 $X=89730 $Y=207680
X1530 1 2 DECAP15JI3V $T=91280 150080 0 0 $X=90850 $Y=149440
X1531 1 2 DECAP15JI3V $T=91840 159040 1 0 $X=91410 $Y=153920
X1532 1 2 DECAP15JI3V $T=94080 123200 1 0 $X=93650 $Y=118080
X1533 1 2 DECAP15JI3V $T=95200 69440 0 0 $X=94770 $Y=68800
X1534 1 2 DECAP15JI3V $T=99680 96320 0 0 $X=99250 $Y=95680
X1535 1 2 DECAP15JI3V $T=100240 78400 0 0 $X=99810 $Y=77760
X1536 1 2 DECAP15JI3V $T=103040 114240 0 0 $X=102610 $Y=113600
X1537 1 2 DECAP15JI3V $T=108080 96320 0 0 $X=107650 $Y=95680
X1538 1 2 DECAP15JI3V $T=123200 78400 1 0 $X=122770 $Y=73280
X1539 1 2 DECAP15JI3V $T=128240 194880 1 0 $X=127810 $Y=189760
X1540 1 2 DECAP15JI3V $T=137760 159040 1 180 $X=128930 $Y=158400
X1541 1 2 DECAP15JI3V $T=131600 78400 0 0 $X=131170 $Y=77760
X1542 1 2 DECAP15JI3V $T=151200 168000 1 0 $X=150770 $Y=162880
X1543 1 2 DECAP15JI3V $T=162960 78400 0 0 $X=162530 $Y=77760
X1544 1 2 DECAP15JI3V $T=210000 87360 1 0 $X=209570 $Y=82240
X1545 1 2 DECAP15JI3V $T=215600 42560 0 0 $X=215170 $Y=41920
X1546 1 2 DECAP15JI3V $T=215600 51520 1 0 $X=215170 $Y=46400
X1547 1 2 DECAP15JI3V $T=223440 33600 0 0 $X=223010 $Y=32960
X1548 1 2 DECAP15JI3V $T=223440 69440 0 0 $X=223010 $Y=68800
X1549 1 2 DECAP15JI3V $T=223440 78400 1 0 $X=223010 $Y=73280
X1550 1 2 DECAP15JI3V $T=223440 96320 1 0 $X=223010 $Y=91200
X1551 1 2 DECAP15JI3V $T=223440 105280 1 0 $X=223010 $Y=100160
X1552 1 2 DECAP15JI3V $T=223440 114240 1 0 $X=223010 $Y=109120
X1553 1 2 DECAP15JI3V $T=229040 114240 0 0 $X=228610 $Y=113600
X1554 1 2 DECAP15JI3V $T=258720 78400 0 0 $X=258290 $Y=77760
X1555 1 2 DECAP15JI3V $T=267120 212800 1 0 $X=266690 $Y=207680
X1556 1 2 DECAP15JI3V $T=268800 212800 0 0 $X=268370 $Y=212160
X1557 1 2 DECAP15JI3V $T=276640 105280 1 0 $X=276210 $Y=100160
X1558 1 2 DECAP15JI3V $T=279440 42560 0 0 $X=279010 $Y=41920
X1559 1 2 DECAP15JI3V $T=280560 185920 0 0 $X=280130 $Y=185280
X1560 1 2 DECAP15JI3V $T=294560 96320 0 0 $X=294130 $Y=95680
X1561 1 2 DECAP15JI3V $T=298480 194880 1 0 $X=298050 $Y=189760
X1562 1 2 DECAP15JI3V $T=300720 114240 1 0 $X=300290 $Y=109120
X1563 1 2 DECAP15JI3V $T=327600 203840 0 0 $X=327170 $Y=203200
X1564 1 2 DECAP15JI3V $T=336000 96320 0 0 $X=335570 $Y=95680
X1565 1 2 DECAP15JI3V $T=337120 96320 1 0 $X=336690 $Y=91200
X1566 1 2 DECAP15JI3V $T=337120 114240 0 0 $X=336690 $Y=113600
X1567 1 2 DECAP15JI3V $T=344960 194880 0 0 $X=344530 $Y=194240
X1568 1 2 DECAP15JI3V $T=350000 105280 1 0 $X=349570 $Y=100160
X1569 1 2 DECAP15JI3V $T=350000 185920 1 0 $X=349570 $Y=180800
X1570 1 2 DECAP15JI3V $T=351680 51520 1 0 $X=351250 $Y=46400
X1571 1 2 DECAP15JI3V $T=351680 69440 0 0 $X=351250 $Y=68800
X1572 1 2 DECAP15JI3V $T=351680 78400 1 0 $X=351250 $Y=73280
X1573 1 2 DECAP15JI3V $T=352240 24640 0 0 $X=351810 $Y=24000
X1574 1 2 DECAP15JI3V $T=381920 141120 1 180 $X=373090 $Y=140480
X1575 1 2 DECAP15JI3V $T=388640 96320 0 180 $X=379810 $Y=91200
X1576 1 2 DECAP15JI3V $T=380800 185920 1 0 $X=380370 $Y=180800
X1577 1 2 DECAP15JI3V $T=381360 78400 1 0 $X=380930 $Y=73280
X1578 1 2 DECAP15JI3V $T=416640 33600 0 180 $X=407810 $Y=28480
X1579 1 2 DECAP15JI3V $T=408240 212800 0 0 $X=407810 $Y=212160
X1580 1 2 DECAP15JI3V $T=411040 114240 0 0 $X=410610 $Y=113600
X1581 1 2 DECAP15JI3V $T=412160 194880 1 0 $X=411730 $Y=189760
X1582 1 2 DECAP15JI3V $T=413280 33600 0 0 $X=412850 $Y=32960
X1583 1 2 DECAP15JI3V $T=413280 60480 1 0 $X=412850 $Y=55360
X1584 1 2 DECAP15JI3V $T=416080 123200 1 0 $X=415650 $Y=118080
X1585 1 2 DECAP15JI3V $T=416080 141120 1 0 $X=415650 $Y=136000
X1586 1 2 DECAP15JI3V $T=418880 42560 0 0 $X=418450 $Y=41920
X1587 1 2 DECAP15JI3V $T=418880 51520 1 0 $X=418450 $Y=46400
X1588 1 2 DECAP15JI3V $T=418880 51520 0 0 $X=418450 $Y=50880
X1589 1 2 DECAP15JI3V $T=420000 24640 1 0 $X=419570 $Y=19520
X1590 1 2 DECAP15JI3V $T=420000 212800 1 0 $X=419570 $Y=207680
X1591 1 2 DECAP15JI3V $T=422800 150080 0 0 $X=422370 $Y=149440
X1592 1 2 DECAP15JI3V $T=422800 176960 0 0 $X=422370 $Y=176320
X1593 1 2 DECAP15JI3V $T=422800 203840 1 0 $X=422370 $Y=198720
X1594 1 2 DECAP15JI3V $T=423920 132160 1 0 $X=423490 $Y=127040
X1595 1 2 DECAP15JI3V $T=426720 132160 0 0 $X=426290 $Y=131520
X1596 1 2 DECAP15JI3V $T=426720 141120 0 0 $X=426290 $Y=140480
X1597 1 2 DECAP15JI3V $T=426720 150080 1 0 $X=426290 $Y=144960
X1598 1 2 DECAP7JI3V $T=20160 105280 1 0 $X=19730 $Y=100160
X1599 1 2 DECAP7JI3V $T=20160 150080 0 0 $X=19730 $Y=149440
X1600 1 2 DECAP7JI3V $T=20160 168000 1 0 $X=19730 $Y=162880
X1601 1 2 DECAP7JI3V $T=20160 168000 0 0 $X=19730 $Y=167360
X1602 1 2 DECAP7JI3V $T=25760 114240 0 0 $X=25330 $Y=113600
X1603 1 2 DECAP7JI3V $T=25760 123200 1 0 $X=25330 $Y=118080
X1604 1 2 DECAP7JI3V $T=25760 176960 0 0 $X=25330 $Y=176320
X1605 1 2 DECAP7JI3V $T=28560 33600 0 0 $X=28130 $Y=32960
X1606 1 2 DECAP7JI3V $T=28560 96320 0 0 $X=28130 $Y=95680
X1607 1 2 DECAP7JI3V $T=32480 33600 0 0 $X=32050 $Y=32960
X1608 1 2 DECAP7JI3V $T=34160 42560 1 0 $X=33730 $Y=37440
X1609 1 2 DECAP7JI3V $T=34160 42560 0 0 $X=33730 $Y=41920
X1610 1 2 DECAP7JI3V $T=34160 51520 1 0 $X=33730 $Y=46400
X1611 1 2 DECAP7JI3V $T=34160 51520 0 0 $X=33730 $Y=50880
X1612 1 2 DECAP7JI3V $T=34160 69440 1 0 $X=33730 $Y=64320
X1613 1 2 DECAP7JI3V $T=34160 78400 0 0 $X=33730 $Y=77760
X1614 1 2 DECAP7JI3V $T=34160 96320 1 0 $X=33730 $Y=91200
X1615 1 2 DECAP7JI3V $T=36400 33600 0 0 $X=35970 $Y=32960
X1616 1 2 DECAP7JI3V $T=36960 123200 1 0 $X=36530 $Y=118080
X1617 1 2 DECAP7JI3V $T=38080 42560 1 0 $X=37650 $Y=37440
X1618 1 2 DECAP7JI3V $T=38080 42560 0 0 $X=37650 $Y=41920
X1619 1 2 DECAP7JI3V $T=38080 51520 1 0 $X=37650 $Y=46400
X1620 1 2 DECAP7JI3V $T=38080 51520 0 0 $X=37650 $Y=50880
X1621 1 2 DECAP7JI3V $T=38080 69440 1 0 $X=37650 $Y=64320
X1622 1 2 DECAP7JI3V $T=38080 96320 1 0 $X=37650 $Y=91200
X1623 1 2 DECAP7JI3V $T=39760 24640 0 0 $X=39330 $Y=24000
X1624 1 2 DECAP7JI3V $T=39760 194880 0 0 $X=39330 $Y=194240
X1625 1 2 DECAP7JI3V $T=40320 33600 0 0 $X=39890 $Y=32960
X1626 1 2 DECAP7JI3V $T=42000 69440 1 0 $X=41570 $Y=64320
X1627 1 2 DECAP7JI3V $T=42560 24640 1 0 $X=42130 $Y=19520
X1628 1 2 DECAP7JI3V $T=42560 203840 0 0 $X=42130 $Y=203200
X1629 1 2 DECAP7JI3V $T=43680 24640 0 0 $X=43250 $Y=24000
X1630 1 2 DECAP7JI3V $T=43680 194880 0 0 $X=43250 $Y=194240
X1631 1 2 DECAP7JI3V $T=46480 24640 1 0 $X=46050 $Y=19520
X1632 1 2 DECAP7JI3V $T=46480 203840 0 0 $X=46050 $Y=203200
X1633 1 2 DECAP7JI3V $T=47600 24640 0 0 $X=47170 $Y=24000
X1634 1 2 DECAP7JI3V $T=50400 24640 1 0 $X=49970 $Y=19520
X1635 1 2 DECAP7JI3V $T=50400 203840 0 0 $X=49970 $Y=203200
X1636 1 2 DECAP7JI3V $T=51520 24640 0 0 $X=51090 $Y=24000
X1637 1 2 DECAP7JI3V $T=54320 203840 0 0 $X=53890 $Y=203200
X1638 1 2 DECAP7JI3V $T=56560 60480 0 0 $X=56130 $Y=59840
X1639 1 2 DECAP7JI3V $T=56560 212800 1 0 $X=56130 $Y=207680
X1640 1 2 DECAP7JI3V $T=59920 51520 0 0 $X=59490 $Y=50880
X1641 1 2 DECAP7JI3V $T=60480 212800 1 0 $X=60050 $Y=207680
X1642 1 2 DECAP7JI3V $T=62160 212800 0 0 $X=61730 $Y=212160
X1643 1 2 DECAP7JI3V $T=62720 194880 0 0 $X=62290 $Y=194240
X1644 1 2 DECAP7JI3V $T=63280 114240 1 0 $X=62850 $Y=109120
X1645 1 2 DECAP7JI3V $T=64400 212800 1 0 $X=63970 $Y=207680
X1646 1 2 DECAP7JI3V $T=66080 212800 0 0 $X=65650 $Y=212160
X1647 1 2 DECAP7JI3V $T=67200 114240 1 0 $X=66770 $Y=109120
X1648 1 2 DECAP7JI3V $T=68320 212800 1 0 $X=67890 $Y=207680
X1649 1 2 DECAP7JI3V $T=70000 212800 0 0 $X=69570 $Y=212160
X1650 1 2 DECAP7JI3V $T=71120 78400 1 0 $X=70690 $Y=73280
X1651 1 2 DECAP7JI3V $T=71120 114240 1 0 $X=70690 $Y=109120
X1652 1 2 DECAP7JI3V $T=71120 132160 0 0 $X=70690 $Y=131520
X1653 1 2 DECAP7JI3V $T=80640 185920 0 0 $X=80210 $Y=185280
X1654 1 2 DECAP7JI3V $T=88480 132160 1 0 $X=88050 $Y=127040
X1655 1 2 DECAP7JI3V $T=90720 194880 0 0 $X=90290 $Y=194240
X1656 1 2 DECAP7JI3V $T=91280 185920 0 0 $X=90850 $Y=185280
X1657 1 2 DECAP7JI3V $T=92400 123200 0 0 $X=91970 $Y=122560
X1658 1 2 DECAP7JI3V $T=92400 132160 1 0 $X=91970 $Y=127040
X1659 1 2 DECAP7JI3V $T=93520 60480 0 0 $X=93090 $Y=59840
X1660 1 2 DECAP7JI3V $T=94640 42560 1 0 $X=94210 $Y=37440
X1661 1 2 DECAP7JI3V $T=94640 42560 0 0 $X=94210 $Y=41920
X1662 1 2 DECAP7JI3V $T=94640 194880 0 0 $X=94210 $Y=194240
X1663 1 2 DECAP7JI3V $T=95200 33600 1 0 $X=94770 $Y=28480
X1664 1 2 DECAP7JI3V $T=95200 69440 1 0 $X=94770 $Y=64320
X1665 1 2 DECAP7JI3V $T=95200 78400 1 0 $X=94770 $Y=73280
X1666 1 2 DECAP7JI3V $T=95200 96320 1 0 $X=94770 $Y=91200
X1667 1 2 DECAP7JI3V $T=95200 114240 1 0 $X=94770 $Y=109120
X1668 1 2 DECAP7JI3V $T=95200 132160 0 0 $X=94770 $Y=131520
X1669 1 2 DECAP7JI3V $T=95200 185920 0 0 $X=94770 $Y=185280
X1670 1 2 DECAP7JI3V $T=95200 203840 0 0 $X=94770 $Y=203200
X1671 1 2 DECAP7JI3V $T=96320 123200 0 0 $X=95890 $Y=122560
X1672 1 2 DECAP7JI3V $T=96320 132160 1 0 $X=95890 $Y=127040
X1673 1 2 DECAP7JI3V $T=96320 176960 1 0 $X=95890 $Y=171840
X1674 1 2 DECAP7JI3V $T=99120 33600 1 0 $X=98690 $Y=28480
X1675 1 2 DECAP7JI3V $T=99120 69440 1 0 $X=98690 $Y=64320
X1676 1 2 DECAP7JI3V $T=99120 78400 1 0 $X=98690 $Y=73280
X1677 1 2 DECAP7JI3V $T=99120 96320 1 0 $X=98690 $Y=91200
X1678 1 2 DECAP7JI3V $T=99120 114240 1 0 $X=98690 $Y=109120
X1679 1 2 DECAP7JI3V $T=99120 132160 0 0 $X=98690 $Y=131520
X1680 1 2 DECAP7JI3V $T=99120 185920 0 0 $X=98690 $Y=185280
X1681 1 2 DECAP7JI3V $T=99120 203840 0 0 $X=98690 $Y=203200
X1682 1 2 DECAP7JI3V $T=99680 150080 0 0 $X=99250 $Y=149440
X1683 1 2 DECAP7JI3V $T=100240 87360 0 0 $X=99810 $Y=86720
X1684 1 2 DECAP7JI3V $T=100240 176960 1 0 $X=99810 $Y=171840
X1685 1 2 DECAP7JI3V $T=100800 159040 0 0 $X=100370 $Y=158400
X1686 1 2 DECAP7JI3V $T=103040 33600 1 0 $X=102610 $Y=28480
X1687 1 2 DECAP7JI3V $T=103040 96320 1 0 $X=102610 $Y=91200
X1688 1 2 DECAP7JI3V $T=103040 114240 1 0 $X=102610 $Y=109120
X1689 1 2 DECAP7JI3V $T=104160 87360 0 0 $X=103730 $Y=86720
X1690 1 2 DECAP7JI3V $T=104720 159040 0 0 $X=104290 $Y=158400
X1691 1 2 DECAP7JI3V $T=105840 194880 1 0 $X=105410 $Y=189760
X1692 1 2 DECAP7JI3V $T=106960 96320 1 0 $X=106530 $Y=91200
X1693 1 2 DECAP7JI3V $T=106960 114240 1 0 $X=106530 $Y=109120
X1694 1 2 DECAP7JI3V $T=111440 114240 0 0 $X=111010 $Y=113600
X1695 1 2 DECAP7JI3V $T=116480 96320 0 0 $X=116050 $Y=95680
X1696 1 2 DECAP7JI3V $T=123200 69440 1 0 $X=122770 $Y=64320
X1697 1 2 DECAP7JI3V $T=128240 105280 0 180 $X=123890 $Y=100160
X1698 1 2 DECAP7JI3V $T=127120 69440 1 0 $X=126690 $Y=64320
X1699 1 2 DECAP7JI3V $T=132160 69440 0 0 $X=131730 $Y=68800
X1700 1 2 DECAP7JI3V $T=132160 87360 0 0 $X=131730 $Y=86720
X1701 1 2 DECAP7JI3V $T=135520 212800 0 0 $X=135090 $Y=212160
X1702 1 2 DECAP7JI3V $T=136080 87360 0 0 $X=135650 $Y=86720
X1703 1 2 DECAP7JI3V $T=138320 33600 0 0 $X=137890 $Y=32960
X1704 1 2 DECAP7JI3V $T=151760 78400 1 0 $X=151330 $Y=73280
X1705 1 2 DECAP7JI3V $T=155680 78400 1 0 $X=155250 $Y=73280
X1706 1 2 DECAP7JI3V $T=155680 203840 1 0 $X=155250 $Y=198720
X1707 1 2 DECAP7JI3V $T=158480 87360 1 0 $X=158050 $Y=82240
X1708 1 2 DECAP7JI3V $T=159600 168000 1 0 $X=159170 $Y=162880
X1709 1 2 DECAP7JI3V $T=162400 33600 0 0 $X=161970 $Y=32960
X1710 1 2 DECAP7JI3V $T=162960 60480 0 0 $X=162530 $Y=59840
X1711 1 2 DECAP7JI3V $T=166320 168000 0 0 $X=165890 $Y=167360
X1712 1 2 DECAP7JI3V $T=166880 60480 0 0 $X=166450 $Y=59840
X1713 1 2 DECAP7JI3V $T=169680 24640 1 0 $X=169250 $Y=19520
X1714 1 2 DECAP7JI3V $T=170240 168000 0 0 $X=169810 $Y=167360
X1715 1 2 DECAP7JI3V $T=170800 60480 0 0 $X=170370 $Y=59840
X1716 1 2 DECAP7JI3V $T=171360 78400 0 0 $X=170930 $Y=77760
X1717 1 2 DECAP7JI3V $T=178080 168000 1 180 $X=173730 $Y=167360
X1718 1 2 DECAP7JI3V $T=174720 60480 0 0 $X=174290 $Y=59840
X1719 1 2 DECAP7JI3V $T=175280 78400 0 0 $X=174850 $Y=77760
X1720 1 2 DECAP7JI3V $T=179200 78400 0 0 $X=178770 $Y=77760
X1721 1 2 DECAP7JI3V $T=184240 69440 0 0 $X=183810 $Y=68800
X1722 1 2 DECAP7JI3V $T=184800 194880 1 0 $X=184370 $Y=189760
X1723 1 2 DECAP7JI3V $T=197680 33600 0 0 $X=197250 $Y=32960
X1724 1 2 DECAP7JI3V $T=197680 60480 1 0 $X=197250 $Y=55360
X1725 1 2 DECAP7JI3V $T=205520 33600 1 180 $X=201170 $Y=32960
X1726 1 2 DECAP7JI3V $T=203280 42560 0 0 $X=202850 $Y=41920
X1727 1 2 DECAP7JI3V $T=215040 69440 1 0 $X=214610 $Y=64320
X1728 1 2 DECAP7JI3V $T=216160 60480 0 0 $X=215730 $Y=59840
X1729 1 2 DECAP7JI3V $T=218400 87360 1 0 $X=217970 $Y=82240
X1730 1 2 DECAP7JI3V $T=218960 69440 1 0 $X=218530 $Y=64320
X1731 1 2 DECAP7JI3V $T=220080 60480 0 0 $X=219650 $Y=59840
X1732 1 2 DECAP7JI3V $T=221200 33600 1 0 $X=220770 $Y=28480
X1733 1 2 DECAP7JI3V $T=221200 212800 0 0 $X=220770 $Y=212160
X1734 1 2 DECAP7JI3V $T=222320 24640 0 0 $X=221890 $Y=24000
X1735 1 2 DECAP7JI3V $T=222320 87360 1 0 $X=221890 $Y=82240
X1736 1 2 DECAP7JI3V $T=222880 69440 1 0 $X=222450 $Y=64320
X1737 1 2 DECAP7JI3V $T=222880 168000 0 0 $X=222450 $Y=167360
X1738 1 2 DECAP7JI3V $T=223440 185920 0 0 $X=223010 $Y=185280
X1739 1 2 DECAP7JI3V $T=224000 42560 0 0 $X=223570 $Y=41920
X1740 1 2 DECAP7JI3V $T=225120 33600 1 0 $X=224690 $Y=28480
X1741 1 2 DECAP7JI3V $T=225120 212800 0 0 $X=224690 $Y=212160
X1742 1 2 DECAP7JI3V $T=225680 212800 1 0 $X=225250 $Y=207680
X1743 1 2 DECAP7JI3V $T=226240 24640 0 0 $X=225810 $Y=24000
X1744 1 2 DECAP7JI3V $T=226240 87360 1 0 $X=225810 $Y=82240
X1745 1 2 DECAP7JI3V $T=226800 168000 0 0 $X=226370 $Y=167360
X1746 1 2 DECAP7JI3V $T=227360 185920 0 0 $X=226930 $Y=185280
X1747 1 2 DECAP7JI3V $T=227920 42560 0 0 $X=227490 $Y=41920
X1748 1 2 DECAP7JI3V $T=229040 78400 0 0 $X=228610 $Y=77760
X1749 1 2 DECAP7JI3V $T=229040 87360 0 0 $X=228610 $Y=86720
X1750 1 2 DECAP7JI3V $T=229040 96320 0 0 $X=228610 $Y=95680
X1751 1 2 DECAP7JI3V $T=229040 105280 0 0 $X=228610 $Y=104640
X1752 1 2 DECAP7JI3V $T=229040 132160 0 0 $X=228610 $Y=131520
X1753 1 2 DECAP7JI3V $T=231840 78400 1 0 $X=231410 $Y=73280
X1754 1 2 DECAP7JI3V $T=231840 123200 1 0 $X=231410 $Y=118080
X1755 1 2 DECAP7JI3V $T=232960 132160 0 0 $X=232530 $Y=131520
X1756 1 2 DECAP7JI3V $T=234080 141120 1 0 $X=233650 $Y=136000
X1757 1 2 DECAP7JI3V $T=235760 78400 1 0 $X=235330 $Y=73280
X1758 1 2 DECAP7JI3V $T=235760 123200 1 0 $X=235330 $Y=118080
X1759 1 2 DECAP7JI3V $T=239680 78400 1 0 $X=239250 $Y=73280
X1760 1 2 DECAP7JI3V $T=243600 78400 1 0 $X=243170 $Y=73280
X1761 1 2 DECAP7JI3V $T=249200 176960 0 180 $X=244850 $Y=171840
X1762 1 2 DECAP7JI3V $T=249200 176960 1 0 $X=248770 $Y=171840
X1763 1 2 DECAP7JI3V $T=251440 96320 1 0 $X=251010 $Y=91200
X1764 1 2 DECAP7JI3V $T=254240 185920 1 0 $X=253810 $Y=180800
X1765 1 2 DECAP7JI3V $T=258720 96320 0 0 $X=258290 $Y=95680
X1766 1 2 DECAP7JI3V $T=262640 96320 0 0 $X=262210 $Y=95680
X1767 1 2 DECAP7JI3V $T=266560 96320 0 0 $X=266130 $Y=95680
X1768 1 2 DECAP7JI3V $T=267120 78400 0 0 $X=266690 $Y=77760
X1769 1 2 DECAP7JI3V $T=267680 78400 1 0 $X=267250 $Y=73280
X1770 1 2 DECAP7JI3V $T=270480 24640 0 0 $X=270050 $Y=24000
X1771 1 2 DECAP7JI3V $T=270480 96320 0 0 $X=270050 $Y=95680
X1772 1 2 DECAP7JI3V $T=271040 78400 0 0 $X=270610 $Y=77760
X1773 1 2 DECAP7JI3V $T=271040 141120 1 0 $X=270610 $Y=136000
X1774 1 2 DECAP7JI3V $T=271040 141120 0 0 $X=270610 $Y=140480
X1775 1 2 DECAP7JI3V $T=271040 150080 1 0 $X=270610 $Y=144960
X1776 1 2 DECAP7JI3V $T=276640 203840 1 0 $X=276210 $Y=198720
X1777 1 2 DECAP7JI3V $T=280560 203840 1 0 $X=280130 $Y=198720
X1778 1 2 DECAP7JI3V $T=284480 203840 1 0 $X=284050 $Y=198720
X1779 1 2 DECAP7JI3V $T=285040 105280 1 0 $X=284610 $Y=100160
X1780 1 2 DECAP7JI3V $T=285600 185920 1 0 $X=285170 $Y=180800
X1781 1 2 DECAP7JI3V $T=288400 203840 1 0 $X=287970 $Y=198720
X1782 1 2 DECAP7JI3V $T=288960 105280 1 0 $X=288530 $Y=100160
X1783 1 2 DECAP7JI3V $T=291200 42560 1 0 $X=290770 $Y=37440
X1784 1 2 DECAP7JI3V $T=292320 132160 0 0 $X=291890 $Y=131520
X1785 1 2 DECAP7JI3V $T=297360 176960 0 0 $X=296930 $Y=176320
X1786 1 2 DECAP7JI3V $T=302960 96320 0 0 $X=302530 $Y=95680
X1787 1 2 DECAP7JI3V $T=306880 96320 0 0 $X=306450 $Y=95680
X1788 1 2 DECAP7JI3V $T=310240 159040 1 0 $X=309810 $Y=153920
X1789 1 2 DECAP7JI3V $T=310800 96320 0 0 $X=310370 $Y=95680
X1790 1 2 DECAP7JI3V $T=314720 78400 0 0 $X=314290 $Y=77760
X1791 1 2 DECAP7JI3V $T=316400 87360 0 0 $X=315970 $Y=86720
X1792 1 2 DECAP7JI3V $T=318640 141120 0 0 $X=318210 $Y=140480
X1793 1 2 DECAP7JI3V $T=320320 87360 0 0 $X=319890 $Y=86720
X1794 1 2 DECAP7JI3V $T=323120 194880 1 0 $X=322690 $Y=189760
X1795 1 2 DECAP7JI3V $T=324240 87360 0 0 $X=323810 $Y=86720
X1796 1 2 DECAP7JI3V $T=325360 123200 1 0 $X=324930 $Y=118080
X1797 1 2 DECAP7JI3V $T=326480 42560 0 0 $X=326050 $Y=41920
X1798 1 2 DECAP7JI3V $T=327040 194880 1 0 $X=326610 $Y=189760
X1799 1 2 DECAP7JI3V $T=329840 203840 1 0 $X=329410 $Y=198720
X1800 1 2 DECAP7JI3V $T=333760 60480 0 0 $X=333330 $Y=59840
X1801 1 2 DECAP7JI3V $T=337680 60480 0 0 $X=337250 $Y=59840
X1802 1 2 DECAP7JI3V $T=342720 51520 1 0 $X=342290 $Y=46400
X1803 1 2 DECAP7JI3V $T=343280 69440 1 0 $X=342850 $Y=64320
X1804 1 2 DECAP7JI3V $T=344400 78400 0 0 $X=343970 $Y=77760
X1805 1 2 DECAP7JI3V $T=344400 96320 0 0 $X=343970 $Y=95680
X1806 1 2 DECAP7JI3V $T=344960 168000 0 0 $X=344530 $Y=167360
X1807 1 2 DECAP7JI3V $T=345520 96320 1 0 $X=345090 $Y=91200
X1808 1 2 DECAP7JI3V $T=345520 114240 0 0 $X=345090 $Y=113600
X1809 1 2 DECAP7JI3V $T=347200 69440 1 0 $X=346770 $Y=64320
X1810 1 2 DECAP7JI3V $T=348320 51520 0 0 $X=347890 $Y=50880
X1811 1 2 DECAP7JI3V $T=348320 78400 0 0 $X=347890 $Y=77760
X1812 1 2 DECAP7JI3V $T=348320 96320 0 0 $X=347890 $Y=95680
X1813 1 2 DECAP7JI3V $T=349440 96320 1 0 $X=349010 $Y=91200
X1814 1 2 DECAP7JI3V $T=349440 114240 0 0 $X=349010 $Y=113600
X1815 1 2 DECAP7JI3V $T=349440 176960 1 0 $X=349010 $Y=171840
X1816 1 2 DECAP7JI3V $T=350000 33600 1 0 $X=349570 $Y=28480
X1817 1 2 DECAP7JI3V $T=351120 69440 1 0 $X=350690 $Y=64320
X1818 1 2 DECAP7JI3V $T=351680 168000 1 0 $X=351250 $Y=162880
X1819 1 2 DECAP7JI3V $T=351680 176960 0 0 $X=351250 $Y=176320
X1820 1 2 DECAP7JI3V $T=352240 60480 1 0 $X=351810 $Y=55360
X1821 1 2 DECAP7JI3V $T=352240 78400 0 0 $X=351810 $Y=77760
X1822 1 2 DECAP7JI3V $T=352240 87360 1 0 $X=351810 $Y=82240
X1823 1 2 DECAP7JI3V $T=352240 87360 0 0 $X=351810 $Y=86720
X1824 1 2 DECAP7JI3V $T=352240 96320 0 0 $X=351810 $Y=95680
X1825 1 2 DECAP7JI3V $T=352240 123200 1 0 $X=351810 $Y=118080
X1826 1 2 DECAP7JI3V $T=352240 123200 0 0 $X=351810 $Y=122560
X1827 1 2 DECAP7JI3V $T=352240 141120 0 0 $X=351810 $Y=140480
X1828 1 2 DECAP7JI3V $T=352240 159040 0 0 $X=351810 $Y=158400
X1829 1 2 DECAP7JI3V $T=353360 96320 1 0 $X=352930 $Y=91200
X1830 1 2 DECAP7JI3V $T=353360 114240 1 0 $X=352930 $Y=109120
X1831 1 2 DECAP7JI3V $T=353360 114240 0 0 $X=352930 $Y=113600
X1832 1 2 DECAP7JI3V $T=353360 176960 1 0 $X=352930 $Y=171840
X1833 1 2 DECAP7JI3V $T=353920 33600 1 0 $X=353490 $Y=28480
X1834 1 2 DECAP7JI3V $T=355040 132160 1 0 $X=354610 $Y=127040
X1835 1 2 DECAP7JI3V $T=355600 176960 0 0 $X=355170 $Y=176320
X1836 1 2 DECAP7JI3V $T=356160 60480 1 0 $X=355730 $Y=55360
X1837 1 2 DECAP7JI3V $T=356160 78400 0 0 $X=355730 $Y=77760
X1838 1 2 DECAP7JI3V $T=356160 87360 1 0 $X=355730 $Y=82240
X1839 1 2 DECAP7JI3V $T=356160 87360 0 0 $X=355730 $Y=86720
X1840 1 2 DECAP7JI3V $T=356160 96320 0 0 $X=355730 $Y=95680
X1841 1 2 DECAP7JI3V $T=356160 123200 1 0 $X=355730 $Y=118080
X1842 1 2 DECAP7JI3V $T=356160 123200 0 0 $X=355730 $Y=122560
X1843 1 2 DECAP7JI3V $T=357280 176960 1 0 $X=356850 $Y=171840
X1844 1 2 DECAP7JI3V $T=373520 168000 1 0 $X=373090 $Y=162880
X1845 1 2 DECAP7JI3V $T=376320 51520 0 0 $X=375890 $Y=50880
X1846 1 2 DECAP7JI3V $T=381360 114240 1 0 $X=380930 $Y=109120
X1847 1 2 DECAP7JI3V $T=382480 105280 1 0 $X=382050 $Y=100160
X1848 1 2 DECAP7JI3V $T=386400 105280 1 0 $X=385970 $Y=100160
X1849 1 2 DECAP7JI3V $T=388640 96320 1 0 $X=388210 $Y=91200
X1850 1 2 DECAP7JI3V $T=390320 105280 1 0 $X=389890 $Y=100160
X1851 1 2 DECAP7JI3V $T=394240 105280 1 0 $X=393810 $Y=100160
X1852 1 2 DECAP7JI3V $T=416640 33600 1 0 $X=416210 $Y=28480
X1853 1 2 DECAP7JI3V $T=416640 78400 1 0 $X=416210 $Y=73280
X1854 1 2 DECAP7JI3V $T=416640 96320 1 0 $X=416210 $Y=91200
X1855 1 2 DECAP7JI3V $T=416640 212800 0 0 $X=416210 $Y=212160
X1856 1 2 DECAP7JI3V $T=419440 114240 0 0 $X=419010 $Y=113600
X1857 1 2 DECAP7JI3V $T=419440 123200 0 0 $X=419010 $Y=122560
X1858 1 2 DECAP7JI3V $T=419440 159040 0 0 $X=419010 $Y=158400
X1859 1 2 DECAP7JI3V $T=420560 33600 1 0 $X=420130 $Y=28480
X1860 1 2 DECAP7JI3V $T=420560 78400 1 0 $X=420130 $Y=73280
X1861 1 2 DECAP7JI3V $T=420560 87360 1 0 $X=420130 $Y=82240
X1862 1 2 DECAP7JI3V $T=420560 96320 1 0 $X=420130 $Y=91200
X1863 1 2 DECAP7JI3V $T=420560 105280 0 0 $X=420130 $Y=104640
X1864 1 2 DECAP7JI3V $T=420560 114240 1 0 $X=420130 $Y=109120
X1865 1 2 DECAP7JI3V $T=420560 194880 1 0 $X=420130 $Y=189760
X1866 1 2 DECAP7JI3V $T=420560 212800 0 0 $X=420130 $Y=212160
X1867 1 2 DECAP7JI3V $T=423360 24640 0 0 $X=422930 $Y=24000
X1868 1 2 DECAP7JI3V $T=423360 114240 0 0 $X=422930 $Y=113600
X1869 1 2 DECAP7JI3V $T=423360 123200 0 0 $X=422930 $Y=122560
X1870 1 2 DECAP7JI3V $T=423360 159040 0 0 $X=422930 $Y=158400
X1871 1 2 DECAP7JI3V $T=423360 176960 1 0 $X=422930 $Y=171840
X1872 1 2 DECAP7JI3V $T=424480 33600 1 0 $X=424050 $Y=28480
X1873 1 2 DECAP7JI3V $T=424480 78400 1 0 $X=424050 $Y=73280
X1874 1 2 DECAP7JI3V $T=424480 87360 1 0 $X=424050 $Y=82240
X1875 1 2 DECAP7JI3V $T=424480 96320 1 0 $X=424050 $Y=91200
X1876 1 2 DECAP7JI3V $T=424480 105280 0 0 $X=424050 $Y=104640
X1877 1 2 DECAP7JI3V $T=424480 114240 1 0 $X=424050 $Y=109120
X1878 1 2 DECAP7JI3V $T=424480 123200 1 0 $X=424050 $Y=118080
X1879 1 2 DECAP7JI3V $T=424480 141120 1 0 $X=424050 $Y=136000
X1880 1 2 DECAP7JI3V $T=424480 194880 1 0 $X=424050 $Y=189760
X1881 1 2 DECAP7JI3V $T=424480 212800 0 0 $X=424050 $Y=212160
X1882 1 2 DECAP7JI3V $T=427280 24640 0 0 $X=426850 $Y=24000
X1883 1 2 DECAP7JI3V $T=427280 33600 0 0 $X=426850 $Y=32960
X1884 1 2 DECAP7JI3V $T=427280 42560 1 0 $X=426850 $Y=37440
X1885 1 2 DECAP7JI3V $T=427280 42560 0 0 $X=426850 $Y=41920
X1886 1 2 DECAP7JI3V $T=427280 51520 1 0 $X=426850 $Y=46400
X1887 1 2 DECAP7JI3V $T=427280 51520 0 0 $X=426850 $Y=50880
X1888 1 2 DECAP7JI3V $T=427280 60480 1 0 $X=426850 $Y=55360
X1889 1 2 DECAP7JI3V $T=427280 60480 0 0 $X=426850 $Y=59840
X1890 1 2 DECAP7JI3V $T=427280 69440 1 0 $X=426850 $Y=64320
X1891 1 2 DECAP7JI3V $T=427280 69440 0 0 $X=426850 $Y=68800
X1892 1 2 DECAP7JI3V $T=427280 87360 0 0 $X=426850 $Y=86720
X1893 1 2 DECAP7JI3V $T=427280 105280 1 0 $X=426850 $Y=100160
X1894 1 2 DECAP7JI3V $T=427280 114240 0 0 $X=426850 $Y=113600
X1895 1 2 DECAP7JI3V $T=427280 123200 0 0 $X=426850 $Y=122560
X1896 1 2 DECAP7JI3V $T=427280 159040 0 0 $X=426850 $Y=158400
X1897 1 2 DECAP7JI3V $T=427280 168000 0 0 $X=426850 $Y=167360
X1898 1 2 DECAP7JI3V $T=427280 176960 1 0 $X=426850 $Y=171840
X1899 1 2 DECAP7JI3V $T=427280 194880 0 0 $X=426850 $Y=194240
X1900 1 2 DECAP7JI3V $T=428400 24640 1 0 $X=427970 $Y=19520
X1901 1 2 DECAP7JI3V $T=428400 33600 1 0 $X=427970 $Y=28480
X1902 1 2 DECAP7JI3V $T=428400 78400 1 0 $X=427970 $Y=73280
X1903 1 2 DECAP7JI3V $T=428400 78400 0 0 $X=427970 $Y=77760
X1904 1 2 DECAP7JI3V $T=428400 87360 1 0 $X=427970 $Y=82240
X1905 1 2 DECAP7JI3V $T=428400 96320 1 0 $X=427970 $Y=91200
X1906 1 2 DECAP7JI3V $T=428400 96320 0 0 $X=427970 $Y=95680
X1907 1 2 DECAP7JI3V $T=428400 105280 0 0 $X=427970 $Y=104640
X1908 1 2 DECAP7JI3V $T=428400 114240 1 0 $X=427970 $Y=109120
X1909 1 2 DECAP7JI3V $T=428400 123200 1 0 $X=427970 $Y=118080
X1910 1 2 DECAP7JI3V $T=428400 141120 1 0 $X=427970 $Y=136000
X1911 1 2 DECAP7JI3V $T=428400 168000 1 0 $X=427970 $Y=162880
X1912 1 2 DECAP7JI3V $T=428400 194880 1 0 $X=427970 $Y=189760
X1913 1 2 DECAP7JI3V $T=428400 212800 1 0 $X=427970 $Y=207680
X1914 1 2 DECAP7JI3V $T=428400 212800 0 0 $X=427970 $Y=212160
X1915 1 2 DECAP7JI3V $T=431200 24640 0 0 $X=430770 $Y=24000
X1916 1 2 DECAP7JI3V $T=431200 33600 0 0 $X=430770 $Y=32960
X1917 1 2 DECAP7JI3V $T=431200 42560 1 0 $X=430770 $Y=37440
X1918 1 2 DECAP7JI3V $T=431200 42560 0 0 $X=430770 $Y=41920
X1919 1 2 DECAP7JI3V $T=431200 51520 1 0 $X=430770 $Y=46400
X1920 1 2 DECAP7JI3V $T=431200 51520 0 0 $X=430770 $Y=50880
X1921 1 2 DECAP7JI3V $T=431200 60480 1 0 $X=430770 $Y=55360
X1922 1 2 DECAP7JI3V $T=431200 60480 0 0 $X=430770 $Y=59840
X1923 1 2 DECAP7JI3V $T=431200 69440 1 0 $X=430770 $Y=64320
X1924 1 2 DECAP7JI3V $T=431200 69440 0 0 $X=430770 $Y=68800
X1925 1 2 DECAP7JI3V $T=431200 87360 0 0 $X=430770 $Y=86720
X1926 1 2 DECAP7JI3V $T=431200 105280 1 0 $X=430770 $Y=100160
X1927 1 2 DECAP7JI3V $T=431200 114240 0 0 $X=430770 $Y=113600
X1928 1 2 DECAP7JI3V $T=431200 123200 0 0 $X=430770 $Y=122560
X1929 1 2 DECAP7JI3V $T=431200 150080 0 0 $X=430770 $Y=149440
X1930 1 2 DECAP7JI3V $T=431200 159040 0 0 $X=430770 $Y=158400
X1931 1 2 DECAP7JI3V $T=431200 168000 0 0 $X=430770 $Y=167360
X1932 1 2 DECAP7JI3V $T=431200 176960 1 0 $X=430770 $Y=171840
X1933 1 2 DECAP7JI3V $T=431200 176960 0 0 $X=430770 $Y=176320
X1934 1 2 DECAP7JI3V $T=431200 185920 1 0 $X=430770 $Y=180800
X1935 1 2 DECAP7JI3V $T=431200 194880 0 0 $X=430770 $Y=194240
X1936 1 2 DECAP7JI3V $T=431200 203840 1 0 $X=430770 $Y=198720
X1937 1 2 DECAP5JI3V $T=20160 105280 0 0 $X=19730 $Y=104640
X1938 1 2 DECAP5JI3V $T=20160 114240 1 0 $X=19730 $Y=109120
X1939 1 2 DECAP5JI3V $T=20160 123200 0 0 $X=19730 $Y=122560
X1940 1 2 DECAP5JI3V $T=20160 132160 1 0 $X=19730 $Y=127040
X1941 1 2 DECAP5JI3V $T=20160 132160 0 0 $X=19730 $Y=131520
X1942 1 2 DECAP5JI3V $T=20160 194880 1 0 $X=19730 $Y=189760
X1943 1 2 DECAP5JI3V $T=36960 114240 0 0 $X=36530 $Y=113600
X1944 1 2 DECAP5JI3V $T=42000 42560 1 0 $X=41570 $Y=37440
X1945 1 2 DECAP5JI3V $T=42000 42560 0 0 $X=41570 $Y=41920
X1946 1 2 DECAP5JI3V $T=42000 51520 1 0 $X=41570 $Y=46400
X1947 1 2 DECAP5JI3V $T=42000 51520 0 0 $X=41570 $Y=50880
X1948 1 2 DECAP5JI3V $T=42560 60480 1 0 $X=42130 $Y=55360
X1949 1 2 DECAP5JI3V $T=48160 176960 1 0 $X=47730 $Y=171840
X1950 1 2 DECAP5JI3V $T=48160 203840 1 0 $X=47730 $Y=198720
X1951 1 2 DECAP5JI3V $T=54320 24640 1 0 $X=53890 $Y=19520
X1952 1 2 DECAP5JI3V $T=59920 42560 1 0 $X=59490 $Y=37440
X1953 1 2 DECAP5JI3V $T=60480 60480 0 0 $X=60050 $Y=59840
X1954 1 2 DECAP5JI3V $T=62160 78400 0 0 $X=61730 $Y=77760
X1955 1 2 DECAP5JI3V $T=62160 87360 0 0 $X=61730 $Y=86720
X1956 1 2 DECAP5JI3V $T=62720 105280 0 0 $X=62290 $Y=104640
X1957 1 2 DECAP5JI3V $T=63280 114240 0 0 $X=62850 $Y=113600
X1958 1 2 DECAP5JI3V $T=67760 159040 1 0 $X=67330 $Y=153920
X1959 1 2 DECAP5JI3V $T=72240 212800 1 0 $X=71810 $Y=207680
X1960 1 2 DECAP5JI3V $T=94080 51520 1 0 $X=93650 $Y=46400
X1961 1 2 DECAP5JI3V $T=94080 51520 0 0 $X=93650 $Y=50880
X1962 1 2 DECAP5JI3V $T=94080 60480 1 0 $X=93650 $Y=55360
X1963 1 2 DECAP5JI3V $T=95760 150080 1 0 $X=95330 $Y=144960
X1964 1 2 DECAP5JI3V $T=98560 185920 1 0 $X=98130 $Y=180800
X1965 1 2 DECAP5JI3V $T=100240 105280 1 0 $X=99810 $Y=100160
X1966 1 2 DECAP5JI3V $T=100240 123200 0 0 $X=99810 $Y=122560
X1967 1 2 DECAP5JI3V $T=100240 132160 1 0 $X=99810 $Y=127040
X1968 1 2 DECAP5JI3V $T=100240 141120 0 0 $X=99810 $Y=140480
X1969 1 2 DECAP5JI3V $T=100240 159040 1 0 $X=99810 $Y=153920
X1970 1 2 DECAP5JI3V $T=107520 105280 0 0 $X=107090 $Y=104640
X1971 1 2 DECAP5JI3V $T=108080 87360 0 0 $X=107650 $Y=86720
X1972 1 2 DECAP5JI3V $T=108640 78400 0 0 $X=108210 $Y=77760
X1973 1 2 DECAP5JI3V $T=110880 114240 1 0 $X=110450 $Y=109120
X1974 1 2 DECAP5JI3V $T=115360 114240 0 0 $X=114930 $Y=113600
X1975 1 2 DECAP5JI3V $T=121520 24640 1 180 $X=118290 $Y=24000
X1976 1 2 DECAP5JI3V $T=119280 168000 0 0 $X=118850 $Y=167360
X1977 1 2 DECAP5JI3V $T=134960 24640 1 0 $X=134530 $Y=19520
X1978 1 2 DECAP5JI3V $T=140000 78400 0 0 $X=139570 $Y=77760
X1979 1 2 DECAP5JI3V $T=140000 87360 0 0 $X=139570 $Y=86720
X1980 1 2 DECAP5JI3V $T=142800 69440 0 0 $X=142370 $Y=68800
X1981 1 2 DECAP5JI3V $T=156240 212800 0 0 $X=155810 $Y=212160
X1982 1 2 DECAP5JI3V $T=159600 78400 1 0 $X=159170 $Y=73280
X1983 1 2 DECAP5JI3V $T=163520 168000 1 0 $X=163090 $Y=162880
X1984 1 2 DECAP5JI3V $T=166320 33600 0 0 $X=165890 $Y=32960
X1985 1 2 DECAP5JI3V $T=179760 60480 1 0 $X=179330 $Y=55360
X1986 1 2 DECAP5JI3V $T=181440 168000 1 0 $X=181010 $Y=162880
X1987 1 2 DECAP5JI3V $T=184240 87360 1 0 $X=183810 $Y=82240
X1988 1 2 DECAP5JI3V $T=184800 42560 1 0 $X=184370 $Y=37440
X1989 1 2 DECAP5JI3V $T=185360 132160 1 0 $X=184930 $Y=127040
X1990 1 2 DECAP5JI3V $T=188720 212800 1 0 $X=188290 $Y=207680
X1991 1 2 DECAP5JI3V $T=197680 51520 1 0 $X=197250 $Y=46400
X1992 1 2 DECAP5JI3V $T=197680 51520 0 0 $X=197250 $Y=50880
X1993 1 2 DECAP5JI3V $T=224000 51520 1 0 $X=223570 $Y=46400
X1994 1 2 DECAP5JI3V $T=224000 60480 0 0 $X=223570 $Y=59840
X1995 1 2 DECAP5JI3V $T=224000 176960 0 0 $X=223570 $Y=176320
X1996 1 2 DECAP5JI3V $T=224000 185920 1 0 $X=223570 $Y=180800
X1997 1 2 DECAP5JI3V $T=228480 141120 0 0 $X=228050 $Y=140480
X1998 1 2 DECAP5JI3V $T=228480 150080 0 0 $X=228050 $Y=149440
X1999 1 2 DECAP5JI3V $T=229040 33600 1 0 $X=228610 $Y=28480
X2000 1 2 DECAP5JI3V $T=229040 212800 0 0 $X=228610 $Y=212160
X2001 1 2 DECAP5JI3V $T=230160 24640 0 0 $X=229730 $Y=24000
X2002 1 2 DECAP5JI3V $T=230160 87360 1 0 $X=229730 $Y=82240
X2003 1 2 DECAP5JI3V $T=230720 168000 0 0 $X=230290 $Y=167360
X2004 1 2 DECAP5JI3V $T=231840 114240 1 0 $X=231410 $Y=109120
X2005 1 2 DECAP5JI3V $T=237440 123200 0 0 $X=237010 $Y=122560
X2006 1 2 DECAP5JI3V $T=244160 33600 1 0 $X=243730 $Y=28480
X2007 1 2 DECAP5JI3V $T=251440 114240 1 0 $X=251010 $Y=109120
X2008 1 2 DECAP5JI3V $T=263760 176960 1 0 $X=263330 $Y=171840
X2009 1 2 DECAP5JI3V $T=272160 132160 1 0 $X=271730 $Y=127040
X2010 1 2 DECAP5JI3V $T=273280 60480 1 0 $X=272850 $Y=55360
X2011 1 2 DECAP5JI3V $T=274400 123200 0 0 $X=273970 $Y=122560
X2012 1 2 DECAP5JI3V $T=276080 203840 0 0 $X=275650 $Y=203200
X2013 1 2 DECAP5JI3V $T=277760 132160 0 0 $X=277330 $Y=131520
X2014 1 2 DECAP5JI3V $T=278320 33600 0 0 $X=277890 $Y=32960
X2015 1 2 DECAP5JI3V $T=285040 33600 1 0 $X=284610 $Y=28480
X2016 1 2 DECAP5JI3V $T=285600 114240 0 0 $X=285170 $Y=113600
X2017 1 2 DECAP5JI3V $T=294000 51520 0 180 $X=290770 $Y=46400
X2018 1 2 DECAP5JI3V $T=291200 51520 0 0 $X=290770 $Y=50880
X2019 1 2 DECAP5JI3V $T=291200 60480 1 0 $X=290770 $Y=55360
X2020 1 2 DECAP5JI3V $T=291200 60480 0 0 $X=290770 $Y=59840
X2021 1 2 DECAP5JI3V $T=291760 96320 1 0 $X=291330 $Y=91200
X2022 1 2 DECAP5JI3V $T=299040 159040 1 0 $X=298610 $Y=153920
X2023 1 2 DECAP5JI3V $T=301840 33600 0 0 $X=301410 $Y=32960
X2024 1 2 DECAP5JI3V $T=306880 194880 1 0 $X=306450 $Y=189760
X2025 1 2 DECAP5JI3V $T=309120 60480 0 0 $X=308690 $Y=59840
X2026 1 2 DECAP5JI3V $T=312480 212800 1 0 $X=312050 $Y=207680
X2027 1 2 DECAP5JI3V $T=314160 114240 0 0 $X=313730 $Y=113600
X2028 1 2 DECAP5JI3V $T=317520 24640 0 0 $X=317090 $Y=24000
X2029 1 2 DECAP5JI3V $T=327040 78400 1 0 $X=326610 $Y=73280
X2030 1 2 DECAP5JI3V $T=327040 194880 0 0 $X=326610 $Y=194240
X2031 1 2 DECAP5JI3V $T=328720 69440 0 0 $X=328290 $Y=68800
X2032 1 2 DECAP5JI3V $T=342720 212800 1 0 $X=342290 $Y=207680
X2033 1 2 DECAP5JI3V $T=352240 51520 0 0 $X=351810 $Y=50880
X2034 1 2 DECAP5JI3V $T=355040 159040 1 0 $X=354610 $Y=153920
X2035 1 2 DECAP5JI3V $T=355600 141120 1 0 $X=355170 $Y=136000
X2036 1 2 DECAP5JI3V $T=355600 150080 1 0 $X=355170 $Y=144960
X2037 1 2 DECAP5JI3V $T=355600 168000 1 0 $X=355170 $Y=162880
X2038 1 2 DECAP5JI3V $T=357280 96320 1 0 $X=356850 $Y=91200
X2039 1 2 DECAP5JI3V $T=357280 114240 0 0 $X=356850 $Y=113600
X2040 1 2 DECAP5JI3V $T=357840 33600 1 0 $X=357410 $Y=28480
X2041 1 2 DECAP5JI3V $T=358400 105280 1 0 $X=357970 $Y=100160
X2042 1 2 DECAP5JI3V $T=362880 51520 0 180 $X=359650 $Y=46400
X2043 1 2 DECAP5JI3V $T=360080 60480 1 0 $X=359650 $Y=55360
X2044 1 2 DECAP5JI3V $T=377440 60480 0 0 $X=377010 $Y=59840
X2045 1 2 DECAP5JI3V $T=383040 132160 0 180 $X=379810 $Y=127040
X2046 1 2 DECAP5JI3V $T=381360 105280 0 0 $X=380930 $Y=104640
X2047 1 2 DECAP5JI3V $T=381360 123200 1 0 $X=380930 $Y=118080
X2048 1 2 DECAP5JI3V $T=381920 114240 0 0 $X=381490 $Y=113600
X2049 1 2 DECAP5JI3V $T=381920 141120 0 0 $X=381490 $Y=140480
X2050 1 2 DECAP5JI3V $T=385840 33600 1 0 $X=385410 $Y=28480
X2051 1 2 DECAP5JI3V $T=393680 150080 1 180 $X=390450 $Y=149440
X2052 1 2 DECAP5JI3V $T=392560 96320 1 0 $X=392130 $Y=91200
X2053 1 2 DECAP5JI3V $T=395360 42560 1 0 $X=394930 $Y=37440
X2054 1 2 DECAP5JI3V $T=395360 42560 0 0 $X=394930 $Y=41920
X2055 1 2 DECAP5JI3V $T=395360 60480 1 0 $X=394930 $Y=55360
X2056 1 2 DECAP5JI3V $T=395360 60480 0 0 $X=394930 $Y=59840
X2057 1 2 DECAP5JI3V $T=395360 69440 1 0 $X=394930 $Y=64320
X2058 1 2 DECAP5JI3V $T=395360 69440 0 0 $X=394930 $Y=68800
X2059 1 2 DECAP5JI3V $T=409360 24640 1 180 $X=406130 $Y=24000
X2060 1 2 DECAP5JI3V $T=432320 24640 1 0 $X=431890 $Y=19520
X2061 1 2 DECAP5JI3V $T=432320 33600 1 0 $X=431890 $Y=28480
X2062 1 2 DECAP5JI3V $T=432320 78400 1 0 $X=431890 $Y=73280
X2063 1 2 DECAP5JI3V $T=432320 78400 0 0 $X=431890 $Y=77760
X2064 1 2 DECAP5JI3V $T=432320 87360 1 0 $X=431890 $Y=82240
X2065 1 2 DECAP5JI3V $T=432320 96320 1 0 $X=431890 $Y=91200
X2066 1 2 DECAP5JI3V $T=432320 96320 0 0 $X=431890 $Y=95680
X2067 1 2 DECAP5JI3V $T=432320 105280 0 0 $X=431890 $Y=104640
X2068 1 2 DECAP5JI3V $T=432320 114240 1 0 $X=431890 $Y=109120
X2069 1 2 DECAP5JI3V $T=432320 123200 1 0 $X=431890 $Y=118080
X2070 1 2 DECAP5JI3V $T=432320 132160 1 0 $X=431890 $Y=127040
X2071 1 2 DECAP5JI3V $T=432320 141120 1 0 $X=431890 $Y=136000
X2072 1 2 DECAP5JI3V $T=432320 159040 1 0 $X=431890 $Y=153920
X2073 1 2 DECAP5JI3V $T=432320 168000 1 0 $X=431890 $Y=162880
X2074 1 2 DECAP5JI3V $T=432320 194880 1 0 $X=431890 $Y=189760
X2075 1 2 DECAP5JI3V $T=432320 212800 1 0 $X=431890 $Y=207680
X2076 1 2 DECAP5JI3V $T=432320 212800 0 0 $X=431890 $Y=212160
X2077 1 2 DECAP10JI3V $T=20160 114240 0 0 $X=19730 $Y=113600
X2078 1 2 DECAP10JI3V $T=20160 123200 1 0 $X=19730 $Y=118080
X2079 1 2 DECAP10JI3V $T=20160 159040 1 0 $X=19730 $Y=153920
X2080 1 2 DECAP10JI3V $T=20160 176960 0 0 $X=19730 $Y=176320
X2081 1 2 DECAP10JI3V $T=20160 185920 0 0 $X=19730 $Y=185280
X2082 1 2 DECAP10JI3V $T=34160 24640 0 0 $X=33730 $Y=24000
X2083 1 2 DECAP10JI3V $T=34160 87360 1 0 $X=33730 $Y=82240
X2084 1 2 DECAP10JI3V $T=34160 194880 0 0 $X=33730 $Y=194240
X2085 1 2 DECAP10JI3V $T=39760 123200 0 0 $X=39330 $Y=122560
X2086 1 2 DECAP10JI3V $T=76160 203840 1 0 $X=75730 $Y=198720
X2087 1 2 DECAP10JI3V $T=77840 141120 0 0 $X=77410 $Y=140480
X2088 1 2 DECAP10JI3V $T=90720 176960 1 0 $X=90290 $Y=171840
X2089 1 2 DECAP10JI3V $T=92960 168000 0 0 $X=92530 $Y=167360
X2090 1 2 DECAP10JI3V $T=95200 159040 0 0 $X=94770 $Y=158400
X2091 1 2 DECAP10JI3V $T=95760 176960 0 0 $X=95330 $Y=176320
X2092 1 2 DECAP10JI3V $T=100240 194880 1 0 $X=99810 $Y=189760
X2093 1 2 DECAP10JI3V $T=140560 176960 1 0 $X=140130 $Y=171840
X2094 1 2 DECAP10JI3V $T=151760 132160 0 0 $X=151330 $Y=131520
X2095 1 2 DECAP10JI3V $T=152880 87360 1 0 $X=152450 $Y=82240
X2096 1 2 DECAP10JI3V $T=204400 123200 1 0 $X=203970 $Y=118080
X2097 1 2 DECAP10JI3V $T=212240 42560 1 0 $X=211810 $Y=37440
X2098 1 2 DECAP10JI3V $T=221200 51520 0 0 $X=220770 $Y=50880
X2099 1 2 DECAP10JI3V $T=223440 78400 0 0 $X=223010 $Y=77760
X2100 1 2 DECAP10JI3V $T=223440 87360 0 0 $X=223010 $Y=86720
X2101 1 2 DECAP10JI3V $T=223440 96320 0 0 $X=223010 $Y=95680
X2102 1 2 DECAP10JI3V $T=223440 105280 0 0 $X=223010 $Y=104640
X2103 1 2 DECAP10JI3V $T=223440 132160 0 0 $X=223010 $Y=131520
X2104 1 2 DECAP10JI3V $T=223440 159040 1 0 $X=223010 $Y=153920
X2105 1 2 DECAP10JI3V $T=224560 176960 1 0 $X=224130 $Y=171840
X2106 1 2 DECAP10JI3V $T=226240 123200 1 0 $X=225810 $Y=118080
X2107 1 2 DECAP10JI3V $T=228480 141120 1 0 $X=228050 $Y=136000
X2108 1 2 DECAP10JI3V $T=243040 150080 1 0 $X=242610 $Y=144960
X2109 1 2 DECAP10JI3V $T=245840 96320 1 0 $X=245410 $Y=91200
X2110 1 2 DECAP10JI3V $T=253120 105280 0 0 $X=252690 $Y=104640
X2111 1 2 DECAP10JI3V $T=283360 150080 0 0 $X=282930 $Y=149440
X2112 1 2 DECAP10JI3V $T=285600 42560 1 0 $X=285170 $Y=37440
X2113 1 2 DECAP10JI3V $T=308560 176960 0 0 $X=308130 $Y=176320
X2114 1 2 DECAP10JI3V $T=309120 78400 0 0 $X=308690 $Y=77760
X2115 1 2 DECAP10JI3V $T=318640 123200 1 0 $X=318210 $Y=118080
X2116 1 2 DECAP10JI3V $T=326480 105280 0 0 $X=326050 $Y=104640
X2117 1 2 DECAP10JI3V $T=338800 78400 0 0 $X=338370 $Y=77760
X2118 1 2 DECAP10JI3V $T=340480 33600 1 0 $X=340050 $Y=28480
X2119 1 2 DECAP10JI3V $T=347760 114240 1 0 $X=347330 $Y=109120
X2120 1 2 DECAP10JI3V $T=352240 42560 1 0 $X=351810 $Y=37440
X2121 1 2 DECAP10JI3V $T=352240 105280 0 0 $X=351810 $Y=104640
X2122 1 2 DECAP10JI3V $T=352240 185920 0 0 $X=351810 $Y=185280
X2123 1 2 DECAP10JI3V $T=352800 168000 0 0 $X=352370 $Y=167360
X2124 1 2 DECAP10JI3V $T=356720 42560 0 0 $X=356290 $Y=41920
X2125 1 2 DECAP10JI3V $T=356720 60480 0 0 $X=356290 $Y=59840
X2126 1 2 DECAP10JI3V $T=373520 185920 0 180 $X=367490 $Y=180800
X2127 1 2 DECAP10JI3V $T=371280 69440 1 0 $X=370850 $Y=64320
X2128 1 2 DECAP10JI3V $T=413840 123200 0 0 $X=413410 $Y=122560
X2129 1 2 DECAP10JI3V $T=413840 159040 0 0 $X=413410 $Y=158400
X2130 1 2 DECAP10JI3V $T=421680 33600 0 0 $X=421250 $Y=32960
X2131 1 2 DECAP10JI3V $T=421680 60480 1 0 $X=421250 $Y=55360
X2132 1 2 DECAP10JI3V $T=421680 87360 0 0 $X=421250 $Y=86720
X2133 1 2 DECAP10JI3V $T=421680 168000 0 0 $X=421250 $Y=167360
D0 2 1 p_dipdnwmv AREA=1.68269e-09 PJ=0.000846738 perimeter=0.000846738 $X=24380 $Y=192640 $dt=19
D1 2 1 p_dipdnwmv AREA=1.71436e-09 PJ=0.000856626 perimeter=0.000856626 $X=29010 $Y=138870 $dt=19
D2 2 1 p_dipdnwmv AREA=1.70244e-09 PJ=0.00085168 perimeter=0.00085168 $X=30130 $Y=120950 $dt=19
D3 2 1 p_dipdnwmv AREA=1.7101e-09 PJ=0.000852491 perimeter=0.000852491 $X=46940 $Y=94080 $dt=19
D4 2 1 p_dipdnwmv AREA=1.72326e-09 PJ=0.000856437 perimeter=0.000856437 $X=69890 $Y=67190 $dt=19
D5 2 1 p_dipdnwmv AREA=1.68194e-09 PJ=0.000847719 perimeter=0.000847719 $X=76460 $Y=210560 $dt=19
D6 2 1 p_dipdnwmv AREA=1.72011e-09 PJ=0.000854508 perimeter=0.000854508 $X=85570 $Y=85110 $dt=19
D7 2 1 p_dipdnwmv AREA=1.68085e-09 PJ=0.000847368 perimeter=0.000847368 $X=85570 $Y=201590 $dt=19
D8 2 1 p_dipdnwmv AREA=1.67889e-09 PJ=0.000849321 perimeter=0.000849321 $X=87810 $Y=165750 $dt=19
D9 2 1 p_dipdnwmv AREA=1.7123e-09 PJ=0.000855368 perimeter=0.000855368 $X=89490 $Y=147830 $dt=19
D10 2 1 p_dipdnwmv AREA=1.66499e-09 PJ=0.000851237 perimeter=0.000851237 $X=117490 $Y=31350 $dt=19
D11 2 1 p_dipdnwmv AREA=1.71216e-09 PJ=0.000861885 perimeter=0.000861885 $X=129810 $Y=40310 $dt=19
D12 2 1 p_dipdnwmv AREA=1.67656e-09 PJ=0.000846569 perimeter=0.000846569 $X=132610 $Y=183670 $dt=19
D13 2 1 p_dipdnwmv AREA=1.72262e-09 PJ=0.000856557 perimeter=0.000856557 $X=146610 $Y=58230 $dt=19
D14 2 1 p_dipdnwmv AREA=1.70024e-09 PJ=0.000851249 perimeter=0.000851249 $X=167890 $Y=111990 $dt=19
D15 2 1 p_dipdnwmv AREA=1.71539e-09 PJ=0.000856066 perimeter=0.000856066 $X=175170 $Y=129910 $dt=19
D16 2 1 p_dipdnwmv AREA=1.71256e-09 PJ=0.000853309 perimeter=0.000853309 $X=191410 $Y=103030 $dt=19
D17 2 1 p_dipdnwmv AREA=1.69697e-09 PJ=0.000852039 perimeter=0.000852039 $X=293890 $Y=156790 $dt=19
D18 2 1 p_dipdnwmv AREA=1.67952e-09 PJ=0.000847075 perimeter=0.000847075 $X=344380 $Y=174710 $dt=19
D19 2 1 p_dipdnwmv AREA=1.64744e-09 PJ=0.0008401 perimeter=0.0008401 $X=386290 $Y=22390 $dt=19
D20 2 1 p_dipdnwmv AREA=1.71423e-09 PJ=0.000853703 perimeter=0.000853703 $X=390210 $Y=76150 $dt=19
D21 2 1 p_dipdnwmv AREA=1.72604e-09 PJ=0.000856428 perimeter=0.000856428 $X=413730 $Y=49270 $dt=19
.ends aska_dig

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: STE_3VX4                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt STE_3VX4 vdd3! gnd! A Q 5
** N=8 EP=5 FDC=15
M0 6 A 7 5 ne3 L=3.5e-07 W=7.6e-07 AD=2.15279e-13 AS=3.648e-13 PD=1.40142e-06 PS=2.48e-06 $X=620 $Y=660 $dt=3
M1 gnd! A 6 5 ne3 L=3.5e-07 W=6.5e-07 AD=5.1e-13 AS=1.84121e-13 PD=3.09e-06 PS=1.19858e-06 $X=1510 $Y=660 $dt=3
M2 vdd3! 7 6 5 ne3 L=3.5e-07 W=8.9e-07 AD=4.628e-13 AS=5.162e-13 PD=2.82e-06 PS=2.94e-06 $X=3790 $Y=660 $dt=3
M3 Q 7 gnd! 5 ne3 L=3.5e-07 W=6.6e-07 AD=1.782e-13 AS=5.8405e-13 PD=1.2e-06 PS=3.57e-06 $X=6040 $Y=865 $dt=3
M4 gnd! 7 Q 5 ne3 L=3.5e-07 W=6.6e-07 AD=3.2115e-13 AS=1.782e-13 PD=1.835e-06 PS=1.2e-06 $X=6930 $Y=865 $dt=3
M5 Q 7 gnd! 5 ne3 L=3.5e-07 W=6.6e-07 AD=1.782e-13 AS=3.2115e-13 PD=1.2e-06 PS=1.835e-06 $X=7900 $Y=865 $dt=3
M6 gnd! 7 Q 5 ne3 L=3.5e-07 W=6.6e-07 AD=6.249e-13 AS=1.782e-13 PD=3.55e-06 PS=1.2e-06 $X=8790 $Y=865 $dt=3
M7 8 A 7 vdd3! pe3 L=3e-07 W=1.41e-06 AD=4.21161e-13 AS=7.1205e-13 PD=2.04348e-06 PS=3.83e-06 $X=645 $Y=2410 $dt=4
M8 vdd3! A 8 vdd3! pe3 L=3e-07 W=1.35e-06 AD=9.5195e-13 AS=4.03239e-13 PD=4.66e-06 PS=1.95652e-06 $X=1535 $Y=2410 $dt=4
M9 gnd! 7 8 vdd3! pe3 L=3.5e-07 W=1.41e-06 AD=6.768e-13 AS=8.178e-13 PD=3.78e-06 PS=3.98e-06 $X=3790 $Y=2410 $dt=4
M10 Q 7 vdd3! vdd3! pe3 L=3e-07 W=1.41e-06 AD=4.1595e-13 AS=9.5945e-13 PD=2e-06 PS=4.66e-06 $X=6145 $Y=2410 $dt=4
M11 vdd3! 7 Q vdd3! pe3 L=3e-07 W=1.41e-06 AD=4.1765e-13 AS=4.1595e-13 PD=2.01e-06 PS=2e-06 $X=7035 $Y=2410 $dt=4
M12 Q 7 vdd3! vdd3! pe3 L=3e-07 W=1.41e-06 AD=4.1595e-13 AS=4.1765e-13 PD=2e-06 PS=2.01e-06 $X=7925 $Y=2410 $dt=4
M13 vdd3! 7 Q vdd3! pe3 L=3e-07 W=1.41e-06 AD=9.8585e-13 AS=4.1595e-13 PD=4.69e-06 PS=2e-06 $X=8815 $Y=2410 $dt=4
D14 5 vdd3! p_dnw3 AREA=3.43516e-11 PJ=2.816e-05 perimeter=2.816e-05 $X=-430 $Y=1980 $dt=36
.ends STE_3VX4

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938374                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938374 1 2 3 4
** N=4 EP=4 FDC=2
M0 3 2 1 4 ne3 L=3.5e-07 W=5e-06 AD=1.35e-12 AS=2.4e-12 PD=5.54e-06 PS=1.096e-05 $X=0 $Y=0 $dt=3
M1 1 2 3 4 ne3 L=3.5e-07 W=5e-06 AD=2.4e-12 AS=1.35e-12 PD=1.096e-05 PS=5.54e-06 $X=890 $Y=0 $dt=3
.ends ne3_CDNS_7290843938374

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ne3_CDNS_7290843938375                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ne3_CDNS_7290843938375 1 2 3 4
** N=4 EP=4 FDC=1
M0 3 2 1 4 ne3 L=5e-06 W=5e-06 AD=2.4e-12 AS=2.4e-12 PD=1.096e-05 PS=1.096e-05 $X=0 $Y=0 $dt=3
.ends ne3_CDNS_7290843938375

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pe3_CDNS_7290843938376                          *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pe3_CDNS_7290843938376 1 2 3 4
*.DEVICECLIMB
** N=5 EP=4 FDC=1
M0 3 2 1 4 pe3 L=5e-07 W=4e-06 AD=1.92e-12 AS=1.92e-12 PD=8.96e-06 PS=8.96e-06 $X=0 $Y=0 $dt=4
.ends pe3_CDNS_7290843938376

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938377                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938377 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.00283888 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938377

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: rpp1k1_3_CDNS_7290843938379                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt rpp1k1_3_CDNS_7290843938379 1 2 3
** N=3 EP=3 FDC=1
R0 2 1 L=0.00411438 W=4e-06 $[rpp1k1_3] $SUB=3 $X=-4220 $Y=0 $dt=37
.ends rpp1k1_3_CDNS_7290843938379

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: por2                                            *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt por2 1 2 3 4 5 6
** N=12 EP=6 FDC=95
X1 2 2 2 2 pe3_CDNS_7290843938322 $T=27155 179685 0 0 $X=25645 $Y=178655
X2 2 2 2 2 pe3_CDNS_7290843938322 $T=27155 197745 0 0 $X=25645 $Y=196715
X3 2 2 2 2 pe3_CDNS_7290843938322 $T=27155 215805 0 0 $X=25645 $Y=214775
X4 2 8 9 2 pe3_CDNS_7290843938322 $T=33395 179685 0 0 $X=31885 $Y=178655
X5 2 8 8 2 pe3_CDNS_7290843938322 $T=33395 197745 0 0 $X=31885 $Y=196715
X6 2 8 9 2 pe3_CDNS_7290843938322 $T=33395 215805 0 0 $X=31885 $Y=214775
X7 2 8 8 2 pe3_CDNS_7290843938322 $T=39635 179685 0 0 $X=38125 $Y=178655
X8 2 8 9 2 pe3_CDNS_7290843938322 $T=39635 197745 0 0 $X=38125 $Y=196715
X9 2 8 8 2 pe3_CDNS_7290843938322 $T=39635 215805 0 0 $X=38125 $Y=214775
X10 2 8 9 2 pe3_CDNS_7290843938322 $T=45875 179685 0 0 $X=44365 $Y=178655
X11 2 8 10 2 pe3_CDNS_7290843938322 $T=45875 197745 0 0 $X=44365 $Y=196715
X12 2 8 9 2 pe3_CDNS_7290843938322 $T=45875 215805 0 0 $X=44365 $Y=214775
X13 2 8 8 2 pe3_CDNS_7290843938322 $T=52115 179685 0 0 $X=50605 $Y=178655
X14 2 8 9 2 pe3_CDNS_7290843938322 $T=52115 197745 0 0 $X=50605 $Y=196715
X15 2 8 8 2 pe3_CDNS_7290843938322 $T=52115 215805 0 0 $X=50605 $Y=214775
X16 2 8 9 2 pe3_CDNS_7290843938322 $T=58355 179685 0 0 $X=56845 $Y=178655
X17 2 8 8 2 pe3_CDNS_7290843938322 $T=58355 197745 0 0 $X=56845 $Y=196715
X18 2 8 9 2 pe3_CDNS_7290843938322 $T=58355 215805 0 0 $X=56845 $Y=214775
X19 2 8 8 2 pe3_CDNS_7290843938322 $T=64595 179685 0 0 $X=63085 $Y=178655
X20 2 8 10 2 pe3_CDNS_7290843938322 $T=64595 197745 0 0 $X=63085 $Y=196715
X21 2 8 8 2 pe3_CDNS_7290843938322 $T=64595 215805 0 0 $X=63085 $Y=214775
X22 2 8 9 2 pe3_CDNS_7290843938322 $T=70835 179685 0 0 $X=69325 $Y=178655
X23 2 8 8 2 pe3_CDNS_7290843938322 $T=70835 197745 0 0 $X=69325 $Y=196715
X24 2 8 9 2 pe3_CDNS_7290843938322 $T=70835 215805 0 0 $X=69325 $Y=214775
X25 2 8 8 2 pe3_CDNS_7290843938322 $T=77075 179685 0 0 $X=75565 $Y=178655
X26 2 2 2 2 pe3_CDNS_7290843938322 $T=77075 197745 0 0 $X=75565 $Y=196715
X27 2 2 2 2 pe3_CDNS_7290843938322 $T=77075 215805 0 0 $X=75565 $Y=214775
X28 2 2 2 2 pe3_CDNS_7290843938322 $T=83315 179685 0 0 $X=81805 $Y=178655
X29 2 2 2 2 pe3_CDNS_7290843938322 $T=83315 197745 0 0 $X=81805 $Y=196715
X30 2 2 2 2 pe3_CDNS_7290843938322 $T=83315 215805 0 0 $X=81805 $Y=214775
X100 1 1 1 6 ne3_CDNS_7290843938351 $T=19735 140745 0 0 $X=18935 $Y=140345
X101 1 1 1 6 ne3_CDNS_7290843938351 $T=19735 155715 0 0 $X=18935 $Y=155315
X102 1 3 3 6 ne3_CDNS_7290843938351 $T=25975 140745 0 0 $X=25175 $Y=140345
X103 1 3 3 6 ne3_CDNS_7290843938351 $T=25975 155715 0 0 $X=25175 $Y=155315
X104 1 3 3 6 ne3_CDNS_7290843938351 $T=32215 140745 0 0 $X=31415 $Y=140345
X105 1 3 3 6 ne3_CDNS_7290843938351 $T=32215 155715 0 0 $X=31415 $Y=155315
X106 1 3 8 6 ne3_CDNS_7290843938351 $T=38455 140745 0 0 $X=37655 $Y=140345
X107 1 3 3 6 ne3_CDNS_7290843938351 $T=38455 155715 0 0 $X=37655 $Y=155315
X108 1 3 3 6 ne3_CDNS_7290843938351 $T=44695 140745 0 0 $X=43895 $Y=140345
X109 1 3 3 6 ne3_CDNS_7290843938351 $T=44695 155715 0 0 $X=43895 $Y=155315
X110 1 3 3 6 ne3_CDNS_7290843938351 $T=50935 140745 0 0 $X=50135 $Y=140345
X111 1 3 3 6 ne3_CDNS_7290843938351 $T=50935 155715 0 0 $X=50135 $Y=155315
X112 1 3 3 6 ne3_CDNS_7290843938351 $T=57175 140745 0 0 $X=56375 $Y=140345
X113 1 1 1 6 ne3_CDNS_7290843938351 $T=57175 155715 0 0 $X=56375 $Y=155315
X114 1 1 1 6 ne3_CDNS_7290843938351 $T=63415 140745 0 0 $X=62615 $Y=140345
X115 1 1 1 6 ne3_CDNS_7290843938351 $T=63415 155715 0 0 $X=62615 $Y=155315
X209 2 1 10 5 6 STE_3VX4 $T=97905 155845 0 0 $X=97475 $Y=155205
X210 1 12 10 6 ne3_CDNS_7290843938374 $T=93475 156435 0 0 $X=92675 $Y=155905
X211 1 11 12 6 ne3_CDNS_7290843938375 $T=79640 140720 0 0 $X=78840 $Y=140320
X212 1 11 11 6 ne3_CDNS_7290843938375 $T=85880 140720 0 0 $X=85080 $Y=140320
X213 9 4 11 2 pe3_CDNS_7290843938376 $T=81690 161500 0 0 $X=80180 $Y=160470
X214 9 7 12 2 pe3_CDNS_7290843938376 $T=83430 161500 0 0 $X=81920 $Y=160470
X215 1 7 6 rpp1k1_3_CDNS_7290843938377 $T=301000 19305 1 90 $X=300780 $Y=14145
X216 7 2 6 rpp1k1_3_CDNS_7290843938379 $T=292340 141005 0 90 $X=121980 $Y=135845
X282 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=15895 $Y=16925 $dt=8
X283 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=15895 $Y=74765 $dt=8
X284 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=68895 $Y=16925 $dt=8
X285 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=68895 $Y=74765 $dt=8
X286 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=121895 $Y=16925 $dt=8
X287 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=121895 $Y=74765 $dt=8
X288 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=174895 $Y=16925 $dt=8
X289 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=174895 $Y=74765 $dt=8
X290 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=227895 $Y=16925 $dt=8
X291 10 1 6 MOSVC3 w=5e-05 l=5e-05 $X=227895 $Y=74765 $dt=8
D10 6 2 p_dnw AREA=2.52272e-09 PJ=0.00028212 perimeter=0.00028212 $X=17665 $Y=173815 $dt=12
D11 6 2 p_dnw AREA=8.09228e-11 PJ=4.5e-05 perimeter=4.5e-05 $X=79040 $Y=154130 $dt=12
D12 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=15095 $Y=16495 $dt=36
D13 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=15095 $Y=74335 $dt=36
D14 6 2 p_dnw3 AREA=7.74011e-10 PJ=0 perimeter=0 $X=25645 $Y=178655 $dt=36
D15 6 2 p_dnw3 AREA=7.74011e-10 PJ=0 perimeter=0 $X=25645 $Y=196715 $dt=36
D16 6 2 p_dnw3 AREA=7.74011e-10 PJ=0 perimeter=0 $X=25645 $Y=214775 $dt=36
D17 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=68095 $Y=16495 $dt=36
D18 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=68095 $Y=74335 $dt=36
D19 6 2 p_dnw3 AREA=3.18756e-11 PJ=0 perimeter=0 $X=80180 $Y=160470 $dt=36
D20 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=121095 $Y=16495 $dt=36
D21 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=121095 $Y=74335 $dt=36
D22 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=174095 $Y=16495 $dt=36
D23 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=174095 $Y=74335 $dt=36
D24 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=227095 $Y=16495 $dt=36
D25 6 1 p_dnw3 AREA=1.24376e-10 PJ=0.00020492 perimeter=0.00020492 $X=227095 $Y=74335 $dt=36
.ends por2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_dhpw_100                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_dhpw_100 K A
*.DEVICECLIMB
** N=3 EP=2 FDC=1
D0 A K dhpw AREA=3.87913e-10 PJ=0.000207812 perimeter=0.000207812 $X=-1440 $Y=-50310 $dt=13
.ends ioh_dhpw_100

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_dhpw_2x100                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_dhpw_2x100 Sub K A
** N=3 EP=3 FDC=3
X0 K A ioh_dhpw_100 $T=-5530 0 1 0 $X=-14660 $Y=-57800
X1 K A ioh_dhpw_100 $T=5530 0 1 0 $X=-3600 $Y=-57800
D0 Sub K ddnw AREA=3.37863e-09 PJ=0.000284404 perimeter=0.000284404 $X=-12340 $Y=-57800 $dt=14
.ends ioh_dhpw_2x100

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_pmbsabhv_2x15_10                            *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_pmbsabhv_2x15_10 1 2 4 5
*.DEVICECLIMB
** N=8 EP=4 FDC=3
R0 4 2 L=5.1e-07 W=1.5e-05 $[rdp_io] $SUB=1 $X=-835 $Y=-7500 $dt=10
R1 2 5 L=5.1e-07 W=1.5e-05 $[rdp_io] $SUB=1 $X=330 $Y=-7500 $dt=10
D2 2 1 dphnw AREA=9.9e-12 PJ=1.32e-06 perimeter=1.32e-06 $X=-330 $Y=-7500 $dt=24
.ends ioh_pmbsabhv_2x15_10

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_pmbsabhv_750                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_pmbsabhv_750 Sub GSB D
** N=53 EP=3 FDC=126
X0 GSB D 4 5 ioh_pmbsabhv_2x15_10 $T=-50640 0 0 0 $X=-53780 $Y=-8460
X1 GSB D 8 9 ioh_pmbsabhv_2x15_10 $T=-46420 0 0 0 $X=-49560 $Y=-8460
X2 GSB D 6 7 ioh_pmbsabhv_2x15_10 $T=-42200 0 0 0 $X=-45340 $Y=-8460
X3 GSB D 10 11 ioh_pmbsabhv_2x15_10 $T=-37980 0 0 0 $X=-41120 $Y=-8460
X4 GSB D 14 15 ioh_pmbsabhv_2x15_10 $T=-33760 0 0 0 $X=-36900 $Y=-8460
X5 GSB D 12 13 ioh_pmbsabhv_2x15_10 $T=-29540 0 0 0 $X=-32680 $Y=-8460
X6 GSB D 16 17 ioh_pmbsabhv_2x15_10 $T=-25320 0 0 0 $X=-28460 $Y=-8460
X7 GSB D 20 21 ioh_pmbsabhv_2x15_10 $T=-21100 0 0 0 $X=-24240 $Y=-8460
X8 GSB D 18 19 ioh_pmbsabhv_2x15_10 $T=-16880 0 0 0 $X=-20020 $Y=-8460
X9 GSB D 22 23 ioh_pmbsabhv_2x15_10 $T=-12660 0 0 0 $X=-15800 $Y=-8460
X10 GSB D 26 27 ioh_pmbsabhv_2x15_10 $T=-8440 0 0 0 $X=-11580 $Y=-8460
X11 GSB D 24 25 ioh_pmbsabhv_2x15_10 $T=-4220 0 0 0 $X=-7360 $Y=-8460
X12 GSB D 28 29 ioh_pmbsabhv_2x15_10 $T=0 0 0 0 $X=-3140 $Y=-8460
X13 GSB D 32 33 ioh_pmbsabhv_2x15_10 $T=4220 0 0 0 $X=1080 $Y=-8460
X14 GSB D 30 31 ioh_pmbsabhv_2x15_10 $T=8440 0 0 0 $X=5300 $Y=-8460
X15 GSB D 34 35 ioh_pmbsabhv_2x15_10 $T=12660 0 0 0 $X=9520 $Y=-8460
X16 GSB D 38 39 ioh_pmbsabhv_2x15_10 $T=16880 0 0 0 $X=13740 $Y=-8460
X17 GSB D 36 37 ioh_pmbsabhv_2x15_10 $T=21100 0 0 0 $X=17960 $Y=-8460
X18 GSB D 40 41 ioh_pmbsabhv_2x15_10 $T=25320 0 0 0 $X=22180 $Y=-8460
X19 GSB D 44 45 ioh_pmbsabhv_2x15_10 $T=29540 0 0 0 $X=26400 $Y=-8460
X20 GSB D 42 43 ioh_pmbsabhv_2x15_10 $T=33760 0 0 0 $X=30620 $Y=-8460
X21 GSB D 46 47 ioh_pmbsabhv_2x15_10 $T=37980 0 0 0 $X=34840 $Y=-8460
X22 GSB D 50 51 ioh_pmbsabhv_2x15_10 $T=42200 0 0 0 $X=39060 $Y=-8460
X23 GSB D 48 49 ioh_pmbsabhv_2x15_10 $T=46420 0 0 0 $X=43280 $Y=-8460
X24 GSB D 52 53 ioh_pmbsabhv_2x15_10 $T=50640 0 0 0 $X=47500 $Y=-8460
M0 4 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=1.47e-11 PD=3.001e-05 PS=3.196e-05 $X=-52480 $Y=-7500 $dt=0
M1 GSB GSB 5 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-49800 $Y=-7500 $dt=0
M2 8 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-48260 $Y=-7500 $dt=0
M3 GSB GSB 9 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-45580 $Y=-7500 $dt=0
M4 6 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-44040 $Y=-7500 $dt=0
M5 GSB GSB 7 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-41360 $Y=-7500 $dt=0
M6 10 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-39820 $Y=-7500 $dt=0
M7 GSB GSB 11 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-37140 $Y=-7500 $dt=0
M8 14 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-35600 $Y=-7500 $dt=0
M9 GSB GSB 15 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-32920 $Y=-7500 $dt=0
M10 12 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-31380 $Y=-7500 $dt=0
M11 GSB GSB 13 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-28700 $Y=-7500 $dt=0
M12 16 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-27160 $Y=-7500 $dt=0
M13 GSB GSB 17 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-24480 $Y=-7500 $dt=0
M14 20 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-22940 $Y=-7500 $dt=0
M15 GSB GSB 21 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-20260 $Y=-7500 $dt=0
M16 18 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-18720 $Y=-7500 $dt=0
M17 GSB GSB 19 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-16040 $Y=-7500 $dt=0
M18 22 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-14500 $Y=-7500 $dt=0
M19 GSB GSB 23 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-11820 $Y=-7500 $dt=0
M20 26 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-10280 $Y=-7500 $dt=0
M21 GSB GSB 27 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-7600 $Y=-7500 $dt=0
M22 24 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-6060 $Y=-7500 $dt=0
M23 GSB GSB 25 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=-3380 $Y=-7500 $dt=0
M24 28 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=-1840 $Y=-7500 $dt=0
M25 GSB GSB 29 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=840 $Y=-7500 $dt=0
M26 32 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=2380 $Y=-7500 $dt=0
M27 GSB GSB 33 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=5060 $Y=-7500 $dt=0
M28 30 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=6600 $Y=-7500 $dt=0
M29 GSB GSB 31 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=9280 $Y=-7500 $dt=0
M30 34 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=10820 $Y=-7500 $dt=0
M31 GSB GSB 35 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=13500 $Y=-7500 $dt=0
M32 38 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=15040 $Y=-7500 $dt=0
M33 GSB GSB 39 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=17720 $Y=-7500 $dt=0
M34 36 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=19260 $Y=-7500 $dt=0
M35 GSB GSB 37 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=21940 $Y=-7500 $dt=0
M36 40 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=23480 $Y=-7500 $dt=0
M37 GSB GSB 41 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=26160 $Y=-7500 $dt=0
M38 44 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=27700 $Y=-7500 $dt=0
M39 GSB GSB 45 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=30380 $Y=-7500 $dt=0
M40 42 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=31920 $Y=-7500 $dt=0
M41 GSB GSB 43 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=34600 $Y=-7500 $dt=0
M42 46 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=36140 $Y=-7500 $dt=0
M43 GSB GSB 47 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=38820 $Y=-7500 $dt=0
M44 50 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=40360 $Y=-7500 $dt=0
M45 GSB GSB 51 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=43040 $Y=-7500 $dt=0
M46 48 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=44580 $Y=-7500 $dt=0
M47 GSB GSB 49 GSB pmb L=1e-06 W=1.5e-05 AD=4.05e-12 AS=7.5e-14 PD=1.554e-05 PS=3.001e-05 $X=47260 $Y=-7500 $dt=0
M48 52 GSB GSB GSB pmb L=1e-06 W=1.5e-05 AD=7.5e-14 AS=4.05e-12 PD=3.001e-05 PS=1.554e-05 $X=48800 $Y=-7500 $dt=0
M49 GSB GSB 53 GSB pmb L=1e-06 W=1.5e-05 AD=1.47e-11 AS=7.5e-14 PD=3.196e-05 PS=3.001e-05 $X=51480 $Y=-7500 $dt=0
D50 Sub GSB ddnw AREA=3.03901e-09 PJ=0.00028418 perimeter=0.00028418 $X=-57930 $Y=-12380 $dt=14
.ends ioh_pmbsabhv_750

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_pe3sab_2x15_04                              *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_pe3sab_2x15_04 1 3 5 6
*.DEVICECLIMB
** N=9 EP=4 FDC=3
R0 5 3 L=4.3e-07 W=1.5e-05 $[rdp3] $SUB=1 $X=-755 $Y=-7500 $dt=30
R1 3 6 L=4.3e-07 W=1.5e-05 $[rdp3] $SUB=1 $X=330 $Y=-7500 $dt=30
D2 3 1 dp3 AREA=9.9e-12 PJ=1.32e-06 perimeter=1.32e-06 $X=-330 $Y=-7500 $dt=33
.ends ioh_pe3sab_2x15_04

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: HVD4SJD1R5PKFs                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt HVD4SJD1R5PKFs GNDO PAD IGND
** N=82 EP=3 FDC=700
X114 GNDO PAD 6 ioh_dhpw_2x100 $T=86930 72000 0 0 $X=67600 $Y=9530
X115 GNDO 6 7 ioh_dhpw_2x100 $T=126250 72000 0 0 $X=106920 $Y=9530
X116 GNDO 7 IGND ioh_dhpw_2x100 $T=165570 72000 0 0 $X=146240 $Y=9530
X117 GNDO PAD 8 ioh_pmbsabhv_750 $T=286780 72000 0 90 $X=268260 $Y=9400
X118 GNDO 8 9 ioh_pmbsabhv_750 $T=323010 72000 0 90 $X=304490 $Y=9400
X119 GNDO 9 10 ioh_pmbsabhv_750 $T=359240 72000 0 90 $X=340720 $Y=9400
X120 GNDO 10 11 ioh_pmbsabhv_750 $T=395470 72000 0 90 $X=376950 $Y=9400
X121 11 5 81 82 ioh_pe3sab_2x15_04 $T=432230 20660 0 90 $X=423770 $Y=18010
X122 11 5 79 80 ioh_pe3sab_2x15_04 $T=432230 23680 0 90 $X=423770 $Y=21030
X123 11 5 77 78 ioh_pe3sab_2x15_04 $T=432230 26700 0 90 $X=423770 $Y=24050
X124 11 5 75 76 ioh_pe3sab_2x15_04 $T=432230 29720 0 90 $X=423770 $Y=27070
X125 11 5 73 74 ioh_pe3sab_2x15_04 $T=432230 32740 0 90 $X=423770 $Y=30090
X126 11 5 71 72 ioh_pe3sab_2x15_04 $T=432230 35760 0 90 $X=423770 $Y=33110
X127 11 5 69 70 ioh_pe3sab_2x15_04 $T=432230 38780 0 90 $X=423770 $Y=36130
X128 11 5 67 68 ioh_pe3sab_2x15_04 $T=432230 41800 0 90 $X=423770 $Y=39150
X129 11 5 65 66 ioh_pe3sab_2x15_04 $T=432230 44820 0 90 $X=423770 $Y=42170
X130 11 5 63 64 ioh_pe3sab_2x15_04 $T=432230 47840 0 90 $X=423770 $Y=45190
X131 11 5 61 62 ioh_pe3sab_2x15_04 $T=432230 50860 0 90 $X=423770 $Y=48210
X132 11 5 59 60 ioh_pe3sab_2x15_04 $T=432230 53880 0 90 $X=423770 $Y=51230
X133 11 5 57 58 ioh_pe3sab_2x15_04 $T=432230 56900 0 90 $X=423770 $Y=54250
X134 11 5 55 56 ioh_pe3sab_2x15_04 $T=432230 59920 0 90 $X=423770 $Y=57270
X135 11 5 53 54 ioh_pe3sab_2x15_04 $T=432230 62940 0 90 $X=423770 $Y=60290
X136 11 5 51 52 ioh_pe3sab_2x15_04 $T=432230 65960 0 90 $X=423770 $Y=63310
X137 11 5 49 50 ioh_pe3sab_2x15_04 $T=432230 68980 0 90 $X=423770 $Y=66330
X138 11 5 47 48 ioh_pe3sab_2x15_04 $T=432230 72000 0 90 $X=423770 $Y=69350
X139 11 5 45 46 ioh_pe3sab_2x15_04 $T=432230 75020 0 90 $X=423770 $Y=72370
X140 11 5 43 44 ioh_pe3sab_2x15_04 $T=432230 78040 0 90 $X=423770 $Y=75390
X141 11 5 41 42 ioh_pe3sab_2x15_04 $T=432230 81060 0 90 $X=423770 $Y=78410
X142 11 5 39 40 ioh_pe3sab_2x15_04 $T=432230 84080 0 90 $X=423770 $Y=81430
X143 11 5 37 38 ioh_pe3sab_2x15_04 $T=432230 87100 0 90 $X=423770 $Y=84450
X144 11 5 35 36 ioh_pe3sab_2x15_04 $T=432230 90120 0 90 $X=423770 $Y=87470
X145 11 5 33 34 ioh_pe3sab_2x15_04 $T=432230 93140 0 90 $X=423770 $Y=90490
X146 11 5 31 32 ioh_pe3sab_2x15_04 $T=432230 96160 0 90 $X=423770 $Y=93510
X147 11 5 29 30 ioh_pe3sab_2x15_04 $T=432230 99180 0 90 $X=423770 $Y=96530
X148 11 5 27 28 ioh_pe3sab_2x15_04 $T=432230 102200 0 90 $X=423770 $Y=99550
X149 11 5 25 26 ioh_pe3sab_2x15_04 $T=432230 105220 0 90 $X=423770 $Y=102570
X150 11 5 23 24 ioh_pe3sab_2x15_04 $T=432230 108240 0 90 $X=423770 $Y=105590
X151 11 5 21 22 ioh_pe3sab_2x15_04 $T=432230 111260 0 90 $X=423770 $Y=108610
X152 11 5 19 20 ioh_pe3sab_2x15_04 $T=432230 114280 0 90 $X=423770 $Y=111630
X153 11 5 17 18 ioh_pe3sab_2x15_04 $T=432230 117300 0 90 $X=423770 $Y=114650
X154 11 5 15 16 ioh_pe3sab_2x15_04 $T=432230 120320 0 90 $X=423770 $Y=117670
X155 11 5 13 14 ioh_pe3sab_2x15_04 $T=432230 123340 0 90 $X=423770 $Y=120690
M0 81 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=1.365e-11 PD=3.001e-05 PS=3.182e-05 $X=424730 $Y=19500 $dt=6
M1 11 12 82 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=21420 $dt=6
M2 79 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=22520 $dt=6
M3 11 12 80 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=24440 $dt=6
M4 77 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=25540 $dt=6
M5 11 12 78 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=27460 $dt=6
M6 75 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=28560 $dt=6
M7 11 12 76 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=30480 $dt=6
M8 73 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=31580 $dt=6
M9 11 12 74 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=33500 $dt=6
M10 71 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=34600 $dt=6
M11 11 12 72 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=36520 $dt=6
M12 69 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=37620 $dt=6
M13 11 12 70 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=39540 $dt=6
M14 67 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=40640 $dt=6
M15 11 12 68 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=42560 $dt=6
M16 65 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=43660 $dt=6
M17 11 12 66 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=45580 $dt=6
M18 63 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=46680 $dt=6
M19 11 12 64 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=48600 $dt=6
M20 61 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=49700 $dt=6
M21 11 12 62 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=51620 $dt=6
M22 59 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=52720 $dt=6
M23 11 12 60 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=54640 $dt=6
M24 57 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=55740 $dt=6
M25 11 12 58 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=57660 $dt=6
M26 55 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=58760 $dt=6
M27 11 12 56 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=60680 $dt=6
M28 53 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=61780 $dt=6
M29 11 12 54 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=63700 $dt=6
M30 51 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=64800 $dt=6
M31 11 12 52 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=66720 $dt=6
M32 49 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=67820 $dt=6
M33 11 12 50 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=69740 $dt=6
M34 47 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=70840 $dt=6
M35 11 12 48 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=72760 $dt=6
M36 45 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=73860 $dt=6
M37 11 12 46 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=75780 $dt=6
M38 43 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=76880 $dt=6
M39 11 12 44 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=78800 $dt=6
M40 41 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=79900 $dt=6
M41 11 12 42 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=81820 $dt=6
M42 39 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=82920 $dt=6
M43 11 12 40 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=84840 $dt=6
M44 37 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=85940 $dt=6
M45 11 12 38 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=87860 $dt=6
M46 35 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=88960 $dt=6
M47 11 12 36 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=90880 $dt=6
M48 33 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=91980 $dt=6
M49 11 12 34 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=93900 $dt=6
M50 31 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=95000 $dt=6
M51 11 12 32 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=96920 $dt=6
M52 29 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=98020 $dt=6
M53 11 12 30 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=99940 $dt=6
M54 27 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=101040 $dt=6
M55 11 12 28 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=102960 $dt=6
M56 25 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=104060 $dt=6
M57 11 12 26 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=105980 $dt=6
M58 23 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=107080 $dt=6
M59 11 12 24 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=109000 $dt=6
M60 21 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=110100 $dt=6
M61 11 12 22 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=112020 $dt=6
M62 19 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=113120 $dt=6
M63 11 12 20 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=115040 $dt=6
M64 17 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=116140 $dt=6
M65 11 12 18 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=118060 $dt=6
M66 15 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=119160 $dt=6
M67 11 12 16 11 pe3i L=4e-07 W=1.5e-05 AD=5.25e-12 AS=7.5e-14 PD=1.57e-05 PS=3.001e-05 $X=424730 $Y=121080 $dt=6
M68 13 12 11 11 pe3i L=4e-07 W=1.5e-05 AD=7.5e-14 AS=5.25e-12 PD=3.001e-05 PS=1.57e-05 $X=424730 $Y=122180 $dt=6
M69 11 12 14 11 pe3i L=4e-07 W=1.5e-05 AD=1.365e-11 AS=7.5e-14 PD=3.182e-05 PS=3.001e-05 $X=424730 $Y=124100 $dt=6
D70 GNDO PAD ddnw AREA=6.92248e-09 PJ=0.000359171 perimeter=0.000359171 $X=192520 $Y=7900 $dt=14
D71 GNDO 11 ddnw AREA=3.10041e-09 PJ=0.00028524 perimeter=0.00028524 $X=417850 $Y=14070 $dt=14
D72 5 PAD dpdd_scr AREA=1.09818e-09 PJ=0.00022858 perimeter=0.00022858 $X=200450 $Y=20150 $dt=21
D73 5 PAD dpdd_scr AREA=1.09818e-09 PJ=0.00022858 perimeter=0.00022858 $X=223500 $Y=20150 $dt=21
D74 5 IGND dnpdd_scr AREA=2.68193e-10 PJ=0.00020478 perimeter=0.00020478 $X=204400 $Y=22150 $dt=22
D75 5 IGND dnpdd_scr AREA=2.68193e-10 PJ=0.00020478 perimeter=0.00020478 $X=227450 $Y=22150 $dt=22
D76 PAD PAD dpdnw AREA=1.89e-10 PJ=0.00020378 perimeter=0.00020378 $X=195560 $Y=22000 $dt=25
D77 PAD PAD dpdnw AREA=1.89e-10 PJ=0.00020378 perimeter=0.00020378 $X=214040 $Y=22000 $dt=25
D78 PAD PAD dpdnw AREA=1.89e-10 PJ=0.00020378 perimeter=0.00020378 $X=218610 $Y=22000 $dt=25
D79 PAD PAD dpdnw AREA=1.89e-10 PJ=0.00020378 perimeter=0.00020378 $X=237090 $Y=22000 $dt=25
R80 11 12 L=2.55e-05 W=4.2e-07 $[rnp1] $X=422670 $Y=97210 $dt=39
R81 IGND 5 L=1.6e-05 W=0.0001 $[rpp1s] $X=250620 $Y=22000 $dt=41
.ends HVD4SJD1R5PKFs

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_resg_pc                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_resg_pc 1 2 4
** N=6 EP=3 FDC=3
R0 2 1 L=3.3e-06 W=4.4e-07 $[rdp3] $SUB=4 $X=4475 $Y=153720 $dt=29
D1 2 4 p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=4475 $Y=152700 $dt=35
D2 1 4 p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=4475 $Y=157020 $dt=35
.ends jio_resg_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_pe3isb_pc                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_pe3isb_pc 2 3 5 6
*.DEVICECLIMB
** N=9 EP=4 FDC=3
R0 6 3 L=2.15e-06 W=3e-05 $[rdp3] $SUB=2 $X=1000 $Y=1825 $dt=30
R1 3 5 L=2.15e-06 W=3e-05 $[rdp3] $SUB=2 $X=3805 $Y=1825 $dt=30
D2 3 2 p_dp3 AREA=1.98e-11 PJ=1.32e-06 perimeter=1.32e-06 $X=3145 $Y=1825 $dt=35
.ends jio_pe3isb_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_base_ptrps_pc                               *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_base_ptrps_pc 1 2 3 4
** N=36 EP=4 FDC=81
X0 1 2 11 12 jio_pe3isb_pc $T=14365 150990 1 180 $X=6700 $Y=149060
X1 1 2 9 10 jio_pe3isb_pc $T=14365 184790 1 180 $X=6700 $Y=182860
X2 1 2 7 8 jio_pe3isb_pc $T=20965 150990 1 180 $X=13300 $Y=149060
X3 1 2 5 6 jio_pe3isb_pc $T=20965 184790 1 180 $X=13300 $Y=182860
X4 1 2 19 20 jio_pe3isb_pc $T=27565 150990 1 180 $X=19900 $Y=149060
X5 1 2 17 18 jio_pe3isb_pc $T=27565 184790 1 180 $X=19900 $Y=182860
X6 1 2 15 16 jio_pe3isb_pc $T=34165 150990 1 180 $X=26500 $Y=149060
X7 1 2 13 14 jio_pe3isb_pc $T=34165 184790 1 180 $X=26500 $Y=182860
X8 1 2 23 24 jio_pe3isb_pc $T=35835 150990 0 0 $X=35120 $Y=149060
X9 1 2 21 22 jio_pe3isb_pc $T=35835 184790 0 0 $X=35120 $Y=182860
X10 1 2 31 32 jio_pe3isb_pc $T=42435 150990 0 0 $X=41720 $Y=149060
X11 1 2 29 30 jio_pe3isb_pc $T=42435 184790 0 0 $X=41720 $Y=182860
X12 1 2 27 28 jio_pe3isb_pc $T=49035 150990 0 0 $X=48320 $Y=149060
X13 1 2 25 26 jio_pe3isb_pc $T=49035 184790 0 0 $X=48320 $Y=182860
X14 1 2 35 36 jio_pe3isb_pc $T=55635 150990 0 0 $X=54920 $Y=149060
X15 1 2 33 34 jio_pe3isb_pc $T=55635 184790 0 0 $X=54920 $Y=182860
M0 11 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=8060 $Y=152815 $dt=6
M1 9 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=8060 $Y=186615 $dt=6
M2 1 3 12 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=13370 $Y=152815 $dt=6
M3 1 3 10 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=13370 $Y=186615 $dt=6
M4 7 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=14660 $Y=152815 $dt=6
M5 5 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=14660 $Y=186615 $dt=6
M6 1 3 8 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=19970 $Y=152815 $dt=6
M7 1 3 6 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=19970 $Y=186615 $dt=6
M8 19 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=21260 $Y=152815 $dt=6
M9 17 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=21260 $Y=186615 $dt=6
M10 1 3 20 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=26570 $Y=152815 $dt=6
M11 1 3 18 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=26570 $Y=186615 $dt=6
M12 15 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=27860 $Y=152815 $dt=6
M13 13 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=27860 $Y=186615 $dt=6
M14 1 3 16 1 pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=33170 $Y=152815 $dt=6
M15 1 3 14 1 pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=33170 $Y=186615 $dt=6
M16 24 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=36480 $Y=152815 $dt=6
M17 22 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=36480 $Y=186615 $dt=6
M18 1 3 23 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=41790 $Y=152815 $dt=6
M19 1 3 21 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=41790 $Y=186615 $dt=6
M20 32 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=43080 $Y=152815 $dt=6
M21 30 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=43080 $Y=186615 $dt=6
M22 1 3 31 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=48390 $Y=152815 $dt=6
M23 1 3 29 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=48390 $Y=186615 $dt=6
M24 28 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=49680 $Y=152815 $dt=6
M25 26 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=49680 $Y=186615 $dt=6
M26 1 3 27 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=54990 $Y=152815 $dt=6
M27 1 3 25 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=54990 $Y=186615 $dt=6
M28 36 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=56280 $Y=152815 $dt=6
M29 34 3 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=56280 $Y=186615 $dt=6
M30 1 3 35 1 pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=61590 $Y=152815 $dt=6
M31 1 3 33 1 pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=61590 $Y=186615 $dt=6
D32 4 1 p_ddnwmv AREA=4.5084e-09 PJ=0.00026872 perimeter=0.00026872 $X=2500 $Y=150035 $dt=17
.ends jio_base_ptrps_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_ne3isb_pc                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_ne3isb_pc 2 3 5 6
*.DEVICECLIMB
** N=9 EP=4 FDC=3
R0 5 3 L=3.35e-06 W=3e-05 $[rdn3] $SUB=2 $X=955 $Y=1825 $dt=27
R1 3 6 L=3.35e-06 W=3e-05 $[rdn3] $SUB=2 $X=4960 $Y=1825 $dt=27
D2 2 3 dn3 AREA=1.98e-11 PJ=1.32e-06 perimeter=1.32e-06 $X=4300 $Y=1825 $dt=31
.ends jio_ne3isb_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_base_ntr_pc                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_base_ntr_pc 1 2 3 4 5
** N=29 EP=5 FDC=62
X100 2 4 8 9 jio_ne3isb_pc $T=16420 75080 1 180 $X=6100 $Y=73130
X101 2 4 6 7 jio_ne3isb_pc $T=16420 108880 1 180 $X=6100 $Y=106930
X102 2 4 12 13 jio_ne3isb_pc $T=25420 75080 1 180 $X=15100 $Y=73130
X103 2 4 10 11 jio_ne3isb_pc $T=25420 108880 1 180 $X=15100 $Y=106930
X104 2 4 16 17 jio_ne3isb_pc $T=34420 75080 1 180 $X=24100 $Y=73130
X105 2 4 14 15 jio_ne3isb_pc $T=34420 108880 1 180 $X=24100 $Y=106930
X106 2 4 20 21 jio_ne3isb_pc $T=35580 75080 0 0 $X=34520 $Y=73130
X107 2 4 18 19 jio_ne3isb_pc $T=35580 108880 0 0 $X=34520 $Y=106930
X108 2 4 24 25 jio_ne3isb_pc $T=44580 75080 0 0 $X=43520 $Y=73130
X109 2 4 22 23 jio_ne3isb_pc $T=44580 108880 0 0 $X=43520 $Y=106930
X110 2 4 28 29 jio_ne3isb_pc $T=53580 75080 0 0 $X=52520 $Y=73130
X111 2 4 26 27 jio_ne3isb_pc $T=53580 108880 0 0 $X=52520 $Y=106930
M0 9 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.89e-11 PD=6.001e-05 PS=6.126e-05 $X=7710 $Y=76905 $dt=5
M1 7 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.89e-11 PD=6.001e-05 PS=6.126e-05 $X=7710 $Y=110705 $dt=5
M2 2 3 8 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=15470 $Y=76905 $dt=5
M3 2 3 6 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=15470 $Y=110705 $dt=5
M4 13 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=16710 $Y=76905 $dt=5
M5 11 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=16710 $Y=110705 $dt=5
M6 2 3 12 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=24470 $Y=76905 $dt=5
M7 2 3 10 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=24470 $Y=110705 $dt=5
M8 17 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=25710 $Y=76905 $dt=5
M9 15 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=25710 $Y=110705 $dt=5
M10 2 3 16 2 ne3i L=4e-07 W=3e-05 AD=3.39e-11 AS=1.5e-13 PD=3.226e-05 PS=6.001e-05 $X=33470 $Y=76905 $dt=5
M11 2 3 14 2 ne3i L=4e-07 W=3e-05 AD=3.39e-11 AS=1.5e-13 PD=3.226e-05 PS=6.001e-05 $X=33470 $Y=110705 $dt=5
M12 20 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=3.39e-11 PD=6.001e-05 PS=3.226e-05 $X=36130 $Y=76905 $dt=5
M13 18 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=3.39e-11 PD=6.001e-05 PS=3.226e-05 $X=36130 $Y=110705 $dt=5
M14 2 3 21 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=43890 $Y=76905 $dt=5
M15 2 3 19 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=43890 $Y=110705 $dt=5
M16 24 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=45130 $Y=76905 $dt=5
M17 22 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=45130 $Y=110705 $dt=5
M18 2 3 25 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=52890 $Y=76905 $dt=5
M19 2 3 23 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=52890 $Y=110705 $dt=5
M20 28 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=54130 $Y=76905 $dt=5
M21 26 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=54130 $Y=110705 $dt=5
M22 2 3 29 2 ne3i L=4e-07 W=3e-05 AD=1.89e-11 AS=1.5e-13 PD=6.126e-05 PS=6.001e-05 $X=61890 $Y=76905 $dt=5
M23 2 3 27 2 ne3i L=4e-07 W=3e-05 AD=1.89e-11 AS=1.5e-13 PD=6.126e-05 PS=6.001e-05 $X=61890 $Y=110705 $dt=5
D24 5 1 ddnwmv AREA=4.69976e-09 PJ=0.00027464 perimeter=0.00027464 $X=2570 $Y=72575 $dt=16
D25 2 1 dipdnwmv AREA=4.16648e-09 PJ=0.00025864 perimeter=0.00025864 $X=4570 $Y=74575 $dt=18
.ends jio_base_ntr_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: APR00DPC                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt APR00DPC PSUB VDDOI PAD GNDOI VDD3I GNDI VDDRI GNDRI
** N=10 EP=8 FDC=149
X0 VDDOI 9 VDDOI jio_resg_pc $T=0 0 0 0 $X=4255 $Y=152520
X1 GNDOI 10 VDDOI jio_resg_pc $T=60610 0 0 0 $X=64865 $Y=152520
X2 VDDOI PAD 9 PSUB jio_base_ptrps_pc $T=0 0 0 0 $X=2500 $Y=149060
X53 VDDOI GNDOI 10 PAD PSUB jio_base_ntr_pc $T=0 0 0 0 $X=2560 $Y=72565
.ends APR00DPC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_pcutdio_pc                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_pcutdio_pc 1 2
** N=5 EP=2 FDC=2
D0 2 1 dp3 AREA=5.88986e-11 PJ=6.40282e-05 perimeter=6.40282e-05 $X=2765 $Y=76075 $dt=32
D1 1 2 dp3 AREA=5.88986e-11 PJ=6.40282e-05 perimeter=6.40282e-05 $X=37455 $Y=78455 $dt=32
.ends jio_pcutdio_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PWRCUTDCPC                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PWRCUTDCPC GNDOI1 PSUB GNDOI2 VDD3I1 VDDOI1 GNDI1 GNDI2 VDD3I2 VDDOI2 VDDRI1
+ GNDRI1 VDDRI2 GNDRI2
** N=20 EP=13 FDC=31
X80 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 0 0 0 $X=1370 $Y=75245
X81 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 4760 0 0 $X=1370 $Y=80005
X82 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 9520 0 0 $X=1370 $Y=84765
X83 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 14280 0 0 $X=1370 $Y=89525
X84 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 19040 0 0 $X=1370 $Y=94285
X85 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 23800 0 0 $X=1370 $Y=99045
X86 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 28560 0 0 $X=1370 $Y=103805
X87 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 33320 0 0 $X=1370 $Y=108565
X88 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 38080 0 0 $X=1370 $Y=113325
X89 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 42840 0 0 $X=1370 $Y=118085
X90 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 47600 0 0 $X=1370 $Y=122845
X91 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 52360 0 0 $X=1370 $Y=127605
X92 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 57120 0 0 $X=1370 $Y=132365
X93 GNDOI1 GNDOI2 jio_pcutdio_pc $T=0 61880 0 0 $X=1370 $Y=137125
D0 GNDOI2 GNDOI1 dp3 AREA=5.88986e-11 PJ=6.40282e-05 perimeter=6.40282e-05 $X=2765 $Y=142715 $dt=32
D1 PSUB GNDOI1 p_dnw3 AREA=2.32916e-09 PJ=0.00020788 perimeter=0.00020788 $X=1310 $Y=74975 $dt=36
D2 PSUB GNDOI2 p_dnw3 AREA=2.32916e-09 PJ=0.00020788 perimeter=0.00020788 $X=36000 $Y=74975 $dt=36
.ends PWRCUTDCPC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: APR04DPC                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt APR04DPC PSUB VDD3I VDDOI GNDOI GNDI PAD Y VDDRI GNDRI
** N=37 EP=9 FDC=139
X0 VDDOI PAD 20 21 jio_pe3isb_pc $T=14365 150990 1 180 $X=6700 $Y=149060
X1 VDDOI PAD 18 19 jio_pe3isb_pc $T=20965 150990 1 180 $X=13300 $Y=149060
X2 VDDOI PAD 16 17 jio_pe3isb_pc $T=27565 150990 1 180 $X=19900 $Y=149060
X3 VDDOI PAD 14 15 jio_pe3isb_pc $T=27565 184790 1 180 $X=19900 $Y=182860
X4 VDDOI PAD 32 33 jio_pe3isb_pc $T=34165 150990 1 180 $X=26500 $Y=149060
X5 VDDOI PAD 30 31 jio_pe3isb_pc $T=34165 184790 1 180 $X=26500 $Y=182860
X6 VDDOI PAD 28 29 jio_pe3isb_pc $T=35835 150990 0 0 $X=35120 $Y=149060
X7 VDDOI PAD 26 27 jio_pe3isb_pc $T=35835 184790 0 0 $X=35120 $Y=182860
X8 VDDOI PAD 24 25 jio_pe3isb_pc $T=42435 150990 0 0 $X=41720 $Y=149060
X9 VDDOI PAD 22 23 jio_pe3isb_pc $T=42435 184790 0 0 $X=41720 $Y=182860
X10 VDDOI PAD 36 37 jio_pe3isb_pc $T=49035 150990 0 0 $X=48320 $Y=149060
X11 VDDOI PAD 34 35 jio_pe3isb_pc $T=55635 150990 0 0 $X=54920 $Y=149060
X236 VDDOI GNDOI 11 PAD PSUB jio_base_ntr_pc $T=0 0 0 0 $X=2560 $Y=72565
M0 11 10 GNDOI GNDOI ne3i L=4e-07 W=1.2e-06 AD=6.36e-13 AS=6.36e-13 PD=3.46e-06 PS=3.46e-06 $X=10900 $Y=212165 $dt=5
M1 12 GNDOI GNDOI GNDOI ne3i L=4e-07 W=1.2e-05 AD=6e-14 AS=6.66e-12 PD=2.401e-05 PS=2.511e-05 $X=59470 $Y=203135 $dt=5
M2 GNDOI GNDOI 13 GNDOI ne3i L=4e-07 W=1.2e-05 AD=6.66e-12 AS=6e-14 PD=2.511e-05 PS=2.401e-05 $X=63170 $Y=203135 $dt=5
M3 20 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=8060 $Y=152815 $dt=6
M4 VDDOI 10 21 VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=13370 $Y=152815 $dt=6
M5 18 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=14660 $Y=152815 $dt=6
M6 VDDOI 10 19 VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=19970 $Y=152815 $dt=6
M7 16 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=21260 $Y=152815 $dt=6
M8 14 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=21260 $Y=186615 $dt=6
M9 VDDOI 10 17 VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=26570 $Y=152815 $dt=6
M10 VDDOI 10 15 VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=26570 $Y=186615 $dt=6
M11 32 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=27860 $Y=152815 $dt=6
M12 30 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=27860 $Y=186615 $dt=6
M13 VDDOI 10 33 VDDOI pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=33170 $Y=152815 $dt=6
M14 VDDOI 10 31 VDDOI pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=33170 $Y=186615 $dt=6
M15 29 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=36480 $Y=152815 $dt=6
M16 27 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=36480 $Y=186615 $dt=6
M17 VDDOI 10 28 VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=41790 $Y=152815 $dt=6
M18 VDDOI 10 26 VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=41790 $Y=186615 $dt=6
M19 25 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=43080 $Y=152815 $dt=6
M20 23 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=43080 $Y=186615 $dt=6
M21 VDDOI 10 24 VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=48390 $Y=152815 $dt=6
M22 VDDOI 10 22 VDDOI pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=48390 $Y=186615 $dt=6
M23 37 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=49680 $Y=152815 $dt=6
M24 Y VDDOI VDDOI VDDOI pe3i L=3.5e-07 W=1.2e-05 AD=6.78e-12 AS=6.24e-12 PD=1.313e-05 PS=2.504e-05 $X=51820 $Y=202785 $dt=6
M25 VDDOI VDDOI Y VDDOI pe3i L=3.5e-07 W=1.2e-05 AD=6.24e-12 AS=6.78e-12 PD=2.504e-05 PS=1.313e-05 $X=53300 $Y=202785 $dt=6
M26 VDDOI 10 36 VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=54990 $Y=152815 $dt=6
M27 35 10 VDDOI VDDOI pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=56280 $Y=152815 $dt=6
M28 VDDOI 10 34 VDDOI pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=61590 $Y=152815 $dt=6
D29 PSUB VDDOI ddnwmv AREA=9.8345e-10 PJ=0.00016026 perimeter=0.00016026 $X=2500 $Y=224395 $dt=16
D30 PSUB VDD3I ddnwmv AREA=9.789e-10 PJ=0.00016012 perimeter=0.00016012 $X=2500 $Y=244525 $dt=16
D31 PSUB VDDOI p_ddnwmv AREA=4.5084e-09 PJ=0.00026872 perimeter=0.00026872 $X=2500 $Y=150035 $dt=17
D32 GNDOI VDDOI dipdnwmv AREA=2.1664e-10 PJ=5.908e-05 perimeter=5.908e-05 $X=4500 $Y=201395 $dt=18
D33 GNDOI VDDOI dipdnwmv AREA=1.2696e-10 PJ=4.787e-05 perimeter=4.787e-05 $X=57565 $Y=201395 $dt=18
R34 12 Y L=1.32e-06 W=1.2e-05 $[rdn3] $SUB=GNDOI $X=59875 $Y=203135 $dt=27
R35 Y 13 L=1.32e-06 W=1.2e-05 $[rdn3] $SUB=GNDOI $X=61850 $Y=203135 $dt=27
R36 10 VDDOI L=3.3e-06 W=4.4e-07 $[rdp3] $SUB=VDDOI $X=14380 $Y=198475 $dt=29
D37 GNDOI Y dn3 AREA=7.92e-12 PJ=1.32e-06 perimeter=1.32e-06 $X=61190 $Y=203135 $dt=31
D38 10 VDDOI p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=13360 $Y=198475 $dt=35
D39 VDDOI VDDOI p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=17680 $Y=198475 $dt=35
R40 PAD Y L=2.2e-06 W=2e-06 $[rpp1] $X=60020 $Y=189980 $dt=40
.ends APR04DPC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_base_ntrc_pc                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_base_ntrc_pc 1 2 3 4 5
** N=29 EP=5 FDC=62
X100 2 4 8 9 jio_ne3isb_pc $T=16420 75080 1 180 $X=6100 $Y=73130
X101 2 4 6 7 jio_ne3isb_pc $T=16420 108880 1 180 $X=6100 $Y=106930
X102 2 4 12 13 jio_ne3isb_pc $T=25420 75080 1 180 $X=15100 $Y=73130
X103 2 4 10 11 jio_ne3isb_pc $T=25420 108880 1 180 $X=15100 $Y=106930
X104 2 4 16 17 jio_ne3isb_pc $T=34420 75080 1 180 $X=24100 $Y=73130
X105 2 4 14 15 jio_ne3isb_pc $T=34420 108880 1 180 $X=24100 $Y=106930
X106 2 4 20 21 jio_ne3isb_pc $T=35580 75080 0 0 $X=34520 $Y=73130
X107 2 4 18 19 jio_ne3isb_pc $T=35580 108880 0 0 $X=34520 $Y=106930
X108 2 4 24 25 jio_ne3isb_pc $T=44580 75080 0 0 $X=43520 $Y=73130
X109 2 4 22 23 jio_ne3isb_pc $T=44580 108880 0 0 $X=43520 $Y=106930
X110 2 4 28 29 jio_ne3isb_pc $T=53580 75080 0 0 $X=52520 $Y=73130
X111 2 4 26 27 jio_ne3isb_pc $T=53580 108880 0 0 $X=52520 $Y=106930
M0 9 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.89e-11 PD=6.001e-05 PS=6.126e-05 $X=7710 $Y=76905 $dt=5
M1 7 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.89e-11 PD=6.001e-05 PS=6.126e-05 $X=7710 $Y=110705 $dt=5
M2 2 3 8 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=15470 $Y=76905 $dt=5
M3 2 3 6 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=15470 $Y=110705 $dt=5
M4 13 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=16710 $Y=76905 $dt=5
M5 11 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=16710 $Y=110705 $dt=5
M6 2 3 12 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=24470 $Y=76905 $dt=5
M7 2 3 10 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=24470 $Y=110705 $dt=5
M8 17 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=25710 $Y=76905 $dt=5
M9 15 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=25710 $Y=110705 $dt=5
M10 2 3 16 2 ne3i L=4e-07 W=3e-05 AD=3.39e-11 AS=1.5e-13 PD=3.226e-05 PS=6.001e-05 $X=33470 $Y=76905 $dt=5
M11 2 3 14 2 ne3i L=4e-07 W=3e-05 AD=3.39e-11 AS=1.5e-13 PD=3.226e-05 PS=6.001e-05 $X=33470 $Y=110705 $dt=5
M12 20 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=3.39e-11 PD=6.001e-05 PS=3.226e-05 $X=36130 $Y=76905 $dt=5
M13 18 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=3.39e-11 PD=6.001e-05 PS=3.226e-05 $X=36130 $Y=110705 $dt=5
M14 2 3 21 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=43890 $Y=76905 $dt=5
M15 2 3 19 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=43890 $Y=110705 $dt=5
M16 24 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=45130 $Y=76905 $dt=5
M17 22 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=45130 $Y=110705 $dt=5
M18 2 3 25 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=52890 $Y=76905 $dt=5
M19 2 3 23 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=52890 $Y=110705 $dt=5
M20 28 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=54130 $Y=76905 $dt=5
M21 26 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=54130 $Y=110705 $dt=5
M22 2 3 29 2 ne3i L=4e-07 W=3e-05 AD=1.89e-11 AS=1.5e-13 PD=6.126e-05 PS=6.001e-05 $X=61890 $Y=76905 $dt=5
M23 2 3 27 2 ne3i L=4e-07 W=3e-05 AD=1.89e-11 AS=1.5e-13 PD=6.126e-05 PS=6.001e-05 $X=61890 $Y=110705 $dt=5
D24 5 1 ddnwmv AREA=4.69976e-09 PJ=0.00027464 perimeter=0.00027464 $X=2570 $Y=72575 $dt=16
D25 2 1 dipdnwmv AREA=4.16648e-09 PJ=0.00025864 perimeter=0.00025864 $X=4570 $Y=74575 $dt=18
.ends jio_base_ntrc_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_basepsc_pc                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_basepsc_pc 1 2 3 4
** N=10 EP=4 FDC=149
X0 2 9 2 jio_resg_pc $T=0 0 0 0 $X=4255 $Y=152520
X1 4 10 2 jio_resg_pc $T=60610 0 0 0 $X=64865 $Y=152520
X2 2 3 9 1 jio_base_ptrps_pc $T=0 0 0 0 $X=2500 $Y=149060
X58 2 4 10 3 1 jio_base_ntrc_pc $T=0 0 0 0 $X=2560 $Y=72565
.ends jio_basepsc_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: GNDPADPC                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt GNDPADPC GNDI VDD3I VDDRI VDDOI GNDRI GNDOI PSUB
** N=7 EP=7 FDC=149
X0 PSUB VDDOI GNDI GNDOI jio_basepsc_pc $T=0 0 0 0 $X=-320 $Y=0
.ends GNDPADPC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_ne3isbg_pc                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_ne3isbg_pc 2 3 5 6
*.DEVICECLIMB
** N=9 EP=4 FDC=3
R0 5 3 L=3.35e-06 W=3e-05 $[rdn3] $SUB=2 $X=955 $Y=1825 $dt=27
R1 3 6 L=3.35e-06 W=3e-05 $[rdn3] $SUB=2 $X=4960 $Y=1825 $dt=27
D2 2 3 dn3 AREA=1.98e-11 PJ=1.32e-06 perimeter=1.32e-06 $X=4300 $Y=1825 $dt=31
.ends jio_ne3isbg_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_base_ngo_pc                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_base_ngo_pc 1 2 3 4
** N=28 EP=4 FDC=62
X1877 2 1 7 8 jio_ne3isbg_pc $T=16420 150990 1 180 $X=6100 $Y=149915
X1878 2 1 5 6 jio_ne3isbg_pc $T=16420 184790 1 180 $X=6100 $Y=183715
X1879 2 1 11 12 jio_ne3isbg_pc $T=25420 150990 1 180 $X=15100 $Y=149915
X1880 2 1 9 10 jio_ne3isbg_pc $T=25420 184790 1 180 $X=15100 $Y=183715
X1881 2 1 15 16 jio_ne3isbg_pc $T=34420 150990 1 180 $X=24100 $Y=149915
X1882 2 1 13 14 jio_ne3isbg_pc $T=34420 184790 1 180 $X=24100 $Y=183715
X1883 2 1 19 20 jio_ne3isbg_pc $T=35580 150990 0 0 $X=34520 $Y=149915
X1884 2 1 17 18 jio_ne3isbg_pc $T=35580 184790 0 0 $X=34520 $Y=183715
X1885 2 1 23 24 jio_ne3isbg_pc $T=44580 150990 0 0 $X=43520 $Y=149915
X1886 2 1 21 22 jio_ne3isbg_pc $T=44580 184790 0 0 $X=43520 $Y=183715
X1887 2 1 27 28 jio_ne3isbg_pc $T=53580 150990 0 0 $X=52520 $Y=149915
X1888 2 1 25 26 jio_ne3isbg_pc $T=53580 184790 0 0 $X=52520 $Y=183715
M0 8 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.89e-11 PD=6.001e-05 PS=6.126e-05 $X=7710 $Y=152815 $dt=5
M1 6 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.89e-11 PD=6.001e-05 PS=6.126e-05 $X=7710 $Y=186615 $dt=5
M2 2 3 7 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=15470 $Y=152815 $dt=5
M3 2 3 5 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=15470 $Y=186615 $dt=5
M4 12 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=16710 $Y=152815 $dt=5
M5 10 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=16710 $Y=186615 $dt=5
M6 2 3 11 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=24470 $Y=152815 $dt=5
M7 2 3 9 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=24470 $Y=186615 $dt=5
M8 16 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=25710 $Y=152815 $dt=5
M9 14 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=25710 $Y=186615 $dt=5
M10 2 3 15 2 ne3i L=4e-07 W=3e-05 AD=3.39e-11 AS=1.5e-13 PD=3.226e-05 PS=6.001e-05 $X=33470 $Y=152815 $dt=5
M11 2 3 13 2 ne3i L=4e-07 W=3e-05 AD=3.39e-11 AS=1.5e-13 PD=3.226e-05 PS=6.001e-05 $X=33470 $Y=186615 $dt=5
M12 19 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=3.39e-11 PD=6.001e-05 PS=3.226e-05 $X=36130 $Y=152815 $dt=5
M13 17 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=3.39e-11 PD=6.001e-05 PS=3.226e-05 $X=36130 $Y=186615 $dt=5
M14 2 3 20 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=43890 $Y=152815 $dt=5
M15 2 3 18 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=43890 $Y=186615 $dt=5
M16 23 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=45130 $Y=152815 $dt=5
M17 21 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=45130 $Y=186615 $dt=5
M18 2 3 24 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=52890 $Y=152815 $dt=5
M19 2 3 22 2 ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=52890 $Y=186615 $dt=5
M20 27 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=54130 $Y=152815 $dt=5
M21 25 3 2 2 ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=54130 $Y=186615 $dt=5
M22 2 3 28 2 ne3i L=4e-07 W=3e-05 AD=1.89e-11 AS=1.5e-13 PD=6.126e-05 PS=6.001e-05 $X=61890 $Y=152815 $dt=5
M23 2 3 26 2 ne3i L=4e-07 W=3e-05 AD=1.89e-11 AS=1.5e-13 PD=6.126e-05 PS=6.001e-05 $X=61890 $Y=186615 $dt=5
D24 4 1 ddnwmv AREA=4.69976e-09 PJ=0.00027464 perimeter=0.00027464 $X=2570 $Y=148485 $dt=16
D25 2 1 dipdnwmv AREA=4.16648e-09 PJ=0.00025864 perimeter=0.00025864 $X=4570 $Y=150485 $dt=18
.ends jio_base_ngo_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: GNDORPADPC                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt GNDORPADPC PSUB VDDOI GNDORI VDD3I GNDI VDDRI
** N=7 EP=6 FDC=66
X113 VDDOI GNDORI 7 PSUB jio_base_ngo_pc $T=0 0 0 0 $X=665 $Y=72575
R0 GNDORI 7 L=3.3e-06 W=4.4e-07 $[rdp3] $SUB=VDDOI $X=4810 $Y=136135 $dt=28
D1 GNDORI VDDOI p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=4810 $Y=135115 $dt=34
D2 7 VDDOI p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=4810 $Y=139435 $dt=34
D3 PSUB VDDOI p_dnw3 AREA=4.54356e-09 PJ=0.00026992 perimeter=0.00026992 $X=2840 $Y=72575 $dt=36
.ends GNDORPADPC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VDDPADPC                                        *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VDDPADPC VDD3I GNDI VDDRI VDDOI GNDRI GNDOI PSUB
** N=7 EP=7 FDC=149
X0 PSUB VDDOI VDD3I GNDOI jio_basepsc_pc $T=0 0 0 0 $X=-320 $Y=0
.ends VDDPADPC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_base_ptrpsfl_pc                             *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_base_ptrpsfl_pc 1 3
** N=3 EP=2 FDC=17
D0 3 1 p_ddnwmv AREA=4.5084e-09 PJ=0.00026872 perimeter=0.00026872 $X=2500 $Y=150035 $dt=17
D1 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=13480 $Y=153600 $dt=35
D2 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=13480 $Y=187400 $dt=35
D3 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=20080 $Y=153600 $dt=35
D4 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=20080 $Y=187400 $dt=35
D5 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=26680 $Y=153600 $dt=35
D6 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=26680 $Y=187400 $dt=35
D7 1 1 p_dp3 AREA=3.4348e-11 PJ=3.018e-05 perimeter=3.018e-05 $X=33280 $Y=153600 $dt=35
D8 1 1 p_dp3 AREA=3.4348e-11 PJ=3.018e-05 perimeter=3.018e-05 $X=33280 $Y=187400 $dt=35
D9 1 1 p_dp3 AREA=3.4348e-11 PJ=3.018e-05 perimeter=3.018e-05 $X=35480 $Y=153600 $dt=35
D10 1 1 p_dp3 AREA=3.4348e-11 PJ=3.018e-05 perimeter=3.018e-05 $X=35480 $Y=187400 $dt=35
D11 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=41900 $Y=153600 $dt=35
D12 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=41900 $Y=187400 $dt=35
D13 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=48500 $Y=153600 $dt=35
D14 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=48500 $Y=187400 $dt=35
D15 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=55100 $Y=153600 $dt=35
D16 1 1 p_dp3 AREA=3.9334e-11 PJ=5.824e-05 perimeter=5.824e-05 $X=55100 $Y=187400 $dt=35
.ends jio_base_ptrpsfl_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: VDDORPADPC                                      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt VDDORPADPC PSUB VDDORI GNDOI VDD3I GNDI GNDRI
** N=7 EP=6 FDC=82
X50 VDDORI GNDOI 7 VDDORI PSUB jio_base_ntr_pc $T=0 0 0 0 $X=2560 $Y=72565
X54 VDDORI PSUB jio_base_ptrpsfl_pc $T=0 0 0 0 $X=510 $Y=137985
R0 7 GNDOI L=3.3e-06 W=4.4e-07 $[rdp3] $SUB=VDDORI $X=65085 $Y=153720 $dt=29
D1 7 VDDORI p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=65085 $Y=152700 $dt=35
D2 GNDOI VDDORI p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=65085 $Y=157020 $dt=35
.ends VDDORPADPC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_bufy_pc                                     *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_bufy_pc 1 2 4 5 6 7
** N=54 EP=6 FDC=38
M0 2 4 9 2 ne3i L=4e-07 W=1.2e-06 AD=4.02e-13 AS=6.12e-13 PD=1.87e-06 PS=3.42e-06 $X=43225 $Y=248510 $dt=5
M1 9 4 2 2 ne3i L=4e-07 W=1.2e-06 AD=6.24e-13 AS=4.02e-13 PD=3.44e-06 PS=1.87e-06 $X=44295 $Y=248510 $dt=5
M2 10 9 2 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=8.064e-13 PD=2.22e-06 PS=4.32e-06 $X=48745 $Y=248340 $dt=5
M3 2 9 10 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=49685 $Y=248340 $dt=5
M4 10 9 2 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=50625 $Y=248340 $dt=5
M5 2 9 10 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=51565 $Y=248340 $dt=5
M6 11 9 2 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=52505 $Y=248340 $dt=5
M7 2 9 11 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=53445 $Y=248340 $dt=5
M8 5 10 2 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=54385 $Y=248340 $dt=5
M9 2 10 5 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=55325 $Y=248340 $dt=5
M10 5 10 2 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=56265 $Y=248340 $dt=5
M11 2 10 5 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=57205 $Y=248340 $dt=5
M12 5 10 2 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=4.536e-13 PD=2.22e-06 PS=2.22e-06 $X=58145 $Y=248340 $dt=5
M13 2 10 5 2 ne3i L=4e-07 W=1.68e-06 AD=8.064e-13 AS=4.536e-13 PD=4.32e-06 PS=2.22e-06 $X=59085 $Y=248340 $dt=5
M14 12 9 6 2 ne3i L=4e-07 W=1.68e-06 AD=4.536e-13 AS=8.064e-13 PD=2.22e-06 PS=4.32e-06 $X=62265 $Y=248110 $dt=5
M15 2 7 12 2 ne3i L=4e-07 W=1.68e-06 AD=8.064e-13 AS=4.536e-13 PD=4.32e-06 PS=2.22e-06 $X=63205 $Y=248110 $dt=5
M16 9 4 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=1.152e-12 PD=2.94e-06 PS=5.76e-06 $X=42235 $Y=254765 $dt=6
M17 1 4 9 1 pe3i L=3.5e-07 W=2.4e-06 AD=1.152e-12 AS=6.48e-13 PD=5.76e-06 PS=2.94e-06 $X=43125 $Y=254765 $dt=6
M18 10 9 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=1.152e-12 PD=2.94e-06 PS=5.76e-06 $X=45125 $Y=254765 $dt=6
M19 1 9 10 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=46015 $Y=254765 $dt=6
M20 11 9 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=46905 $Y=254765 $dt=6
M21 1 9 11 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=47795 $Y=254765 $dt=6
M22 11 9 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=48685 $Y=254765 $dt=6
M23 1 9 11 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=49575 $Y=254765 $dt=6
M24 11 9 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=50465 $Y=254765 $dt=6
M25 1 9 11 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=51355 $Y=254765 $dt=6
M26 5 11 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=52245 $Y=254765 $dt=6
M27 1 11 5 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=53135 $Y=254765 $dt=6
M28 5 11 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=54025 $Y=254765 $dt=6
M29 1 11 5 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=54915 $Y=254765 $dt=6
M30 5 11 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=55805 $Y=254765 $dt=6
M31 1 11 5 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=56695 $Y=254765 $dt=6
M32 5 11 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=57585 $Y=254765 $dt=6
M33 1 11 5 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=58475 $Y=254765 $dt=6
M34 5 11 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=6.48e-13 PD=2.94e-06 PS=2.94e-06 $X=59365 $Y=254765 $dt=6
M35 1 11 5 1 pe3i L=3.5e-07 W=2.4e-06 AD=1.152e-12 AS=6.48e-13 PD=5.76e-06 PS=2.94e-06 $X=60255 $Y=254765 $dt=6
M36 6 9 1 1 pe3i L=3.5e-07 W=2.4e-06 AD=6.48e-13 AS=1.248e-12 PD=2.94e-06 PS=5.84e-06 $X=62365 $Y=254765 $dt=6
M37 1 7 6 1 pe3i L=3.5e-07 W=2.4e-06 AD=1.152e-12 AS=6.48e-13 PD=5.76e-06 PS=2.94e-06 $X=63255 $Y=254765 $dt=6
.ends jio_bufy_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_bufc_lay_pc                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_bufc_lay_pc 1 2 3 4
** N=14 EP=4 FDC=9
M0 4 2 1 4 ne3i L=4e-07 W=2e-06 AD=5.4e-13 AS=9.6e-13 PD=2.54e-06 PS=4.96e-06 $X=55490 $Y=228495 $dt=5
M1 1 2 4 4 ne3i L=4e-07 W=2e-06 AD=5.4e-13 AS=5.4e-13 PD=2.54e-06 PS=2.54e-06 $X=56430 $Y=228495 $dt=5
M2 4 2 1 4 ne3i L=4e-07 W=2e-06 AD=9.6e-13 AS=5.4e-13 PD=4.96e-06 PS=2.54e-06 $X=57370 $Y=228495 $dt=5
M3 1 2 3 3 pe3i L=3.5e-07 W=2.2e-06 AD=6.49e-13 AS=1.111e-12 PD=2.79e-06 PS=5.41e-06 $X=55515 $Y=234765 $dt=6
M4 3 2 1 3 pe3i L=3.5e-07 W=2.2e-06 AD=6.49e-13 AS=6.49e-13 PD=2.79e-06 PS=2.79e-06 $X=56455 $Y=234765 $dt=6
M5 1 2 3 3 pe3i L=3.5e-07 W=2.2e-06 AD=6.49e-13 AS=6.49e-13 PD=2.79e-06 PS=2.79e-06 $X=57395 $Y=234765 $dt=6
M6 3 2 1 3 pe3i L=3.5e-07 W=2.2e-06 AD=6.49e-13 AS=6.49e-13 PD=2.79e-06 PS=2.79e-06 $X=58335 $Y=234765 $dt=6
M7 1 2 3 3 pe3i L=3.5e-07 W=2.2e-06 AD=6.49e-13 AS=6.49e-13 PD=2.79e-06 PS=2.79e-06 $X=59275 $Y=234765 $dt=6
M8 3 2 1 3 pe3i L=3.5e-07 W=2.2e-06 AD=1.111e-12 AS=6.49e-13 PD=5.41e-06 PS=2.79e-06 $X=60215 $Y=234765 $dt=6
.ends jio_bufc_lay_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: jio_base_ptr_pc                                 *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt jio_base_ptr_pc 1 2 3 4 5 30
** N=30 EP=6 FDC=64
X10 1 3 8 9 jio_pe3isb_pc $T=14365 150990 1 180 $X=6700 $Y=149060
X11 1 3 6 7 jio_pe3isb_pc $T=20965 150990 1 180 $X=13300 $Y=149060
X12 1 3 16 17 jio_pe3isb_pc $T=27565 150990 1 180 $X=19900 $Y=149060
X13 1 3 14 15 jio_pe3isb_pc $T=27565 184790 1 180 $X=19900 $Y=182860
X14 1 3 12 13 jio_pe3isb_pc $T=34165 150990 1 180 $X=26500 $Y=149060
X15 1 3 10 11 jio_pe3isb_pc $T=34165 184790 1 180 $X=26500 $Y=182860
X16 1 3 20 21 jio_pe3isb_pc $T=35835 150990 0 0 $X=35120 $Y=149060
X17 1 3 18 19 jio_pe3isb_pc $T=35835 184790 0 0 $X=35120 $Y=182860
X18 1 3 26 27 jio_pe3isb_pc $T=42435 150990 0 0 $X=41720 $Y=149060
X19 1 3 24 25 jio_pe3isb_pc $T=42435 184790 0 0 $X=41720 $Y=182860
X20 1 3 22 23 jio_pe3isb_pc $T=49035 150990 0 0 $X=48320 $Y=149060
X21 1 3 28 29 jio_pe3isb_pc $T=55635 150990 0 0 $X=54920 $Y=149060
M0 8 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=8060 $Y=152815 $dt=6
M1 1 4 9 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=13370 $Y=152815 $dt=6
M2 6 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=14660 $Y=152815 $dt=6
M3 1 4 7 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=19970 $Y=152815 $dt=6
M4 16 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=21260 $Y=152815 $dt=6
M5 14 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=21260 $Y=186615 $dt=6
M6 1 4 17 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=26570 $Y=152815 $dt=6
M7 1 4 15 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=26570 $Y=186615 $dt=6
M8 12 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=27860 $Y=152815 $dt=6
M9 10 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=27860 $Y=186615 $dt=6
M10 1 4 13 1 pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=33170 $Y=152815 $dt=6
M11 1 4 11 1 pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=33170 $Y=186615 $dt=6
M12 21 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=36480 $Y=152815 $dt=6
M13 19 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=2.04e-11 PD=6.001e-05 PS=6.136e-05 $X=36480 $Y=186615 $dt=6
M14 1 4 20 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=41790 $Y=152815 $dt=6
M15 1 4 18 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=41790 $Y=186615 $dt=6
M16 27 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=43080 $Y=152815 $dt=6
M17 25 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=43080 $Y=186615 $dt=6
M18 1 4 26 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=48390 $Y=152815 $dt=6
M19 1 4 24 1 pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=48390 $Y=186615 $dt=6
M20 23 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=49680 $Y=152815 $dt=6
M21 1 4 22 1 pe3i L=3.5e-07 W=3e-05 AD=1.41e-11 AS=1.5e-13 PD=3.094e-05 PS=6.001e-05 $X=54990 $Y=152815 $dt=6
M22 29 4 1 1 pe3i L=3.5e-07 W=3e-05 AD=1.5e-13 AS=1.41e-11 PD=6.001e-05 PS=3.094e-05 $X=56280 $Y=152815 $dt=6
M23 1 4 28 1 pe3i L=3.5e-07 W=3e-05 AD=2.04e-11 AS=1.5e-13 PD=6.136e-05 PS=6.001e-05 $X=61590 $Y=152815 $dt=6
D24 5 1 p_ddnwmv AREA=4.5084e-09 PJ=0.00026872 perimeter=0.00026872 $X=2500 $Y=150035 $dt=17
D25 2 1 dipdnwmv AREA=2.1664e-10 PJ=5.908e-05 perimeter=5.908e-05 $X=4500 $Y=201395 $dt=18
D26 2 1 dipdnwmv AREA=2.1664e-10 PJ=5.908e-05 perimeter=5.908e-05 $X=51960 $Y=201395 $dt=18
D27 2 30 dn3 AREA=7.92e-12 PJ=1.32e-06 perimeter=1.32e-06 $X=55585 $Y=203375 $dt=31
.ends jio_base_ptr_pc

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ICPC                                            *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ICPC PSUB VDDOI VDD3I GNDI GNDOI VDDRI GNDRI PAD Y PO
+ PI
** N=22 EP=11 FDC=190
X12 VDDOI GNDOI 13 PAD PSUB jio_base_ntr_pc $T=0 0 0 0 $X=2560 $Y=72565
X152 VDD3I GNDI 15 Y PO PI jio_bufy_pc $T=0 0 0 0 $X=30485 $Y=244955
X153 15 16 VDDRI GNDRI jio_bufc_lay_pc $T=0 0 0 0 $X=45750 $Y=220155
X157 VDDOI GNDOI PAD 12 PSUB 16 jio_base_ptr_pc $T=0 0 0 0 $X=2500 $Y=149060
M0 13 12 GNDOI GNDOI ne3i L=4e-07 W=1.2e-06 AD=6.36e-13 AS=6.36e-13 PD=3.46e-06 PS=3.46e-06 $X=10900 $Y=214545 $dt=5
M1 17 GNDOI GNDOI GNDOI ne3i L=4e-07 W=1.2e-05 AD=6e-14 AS=6.66e-12 PD=2.401e-05 PS=2.511e-05 $X=53865 $Y=203375 $dt=5
M2 GNDOI GNDOI 18 GNDOI ne3i L=4e-07 W=1.2e-05 AD=6.66e-12 AS=6e-14 PD=2.511e-05 PS=2.401e-05 $X=57565 $Y=203375 $dt=5
M3 16 VDDOI VDDOI VDDOI pe3i L=3.5e-07 W=1.2e-05 AD=6.78e-12 AS=6.24e-12 PD=1.313e-05 PS=2.504e-05 $X=22325 $Y=234735 $dt=6
M4 VDDOI VDDOI 16 VDDOI pe3i L=3.5e-07 W=1.2e-05 AD=6.24e-12 AS=6.78e-12 PD=2.504e-05 PS=1.313e-05 $X=22325 $Y=236215 $dt=6
D5 PSUB VDDOI ddnwmv AREA=5.2955e-10 PJ=0.00010026 perimeter=0.00010026 $X=2500 $Y=224395 $dt=16
D6 PSUB VDDRI ddnwmv AREA=3.7825e-10 PJ=8.026e-05 perimeter=8.026e-05 $X=42500 $Y=224395 $dt=16
D7 PSUB VDD3I p_ddnwmv AREA=9.789e-10 PJ=0.00016012 perimeter=0.00016012 $X=2500 $Y=244525 $dt=17
D8 GNDOI VDDOI dipdnwmv AREA=1.9592e-10 PJ=7.464e-05 perimeter=7.464e-05 $X=4500 $Y=226395 $dt=18
D9 GNDI VDD3I dipdnwmv AREA=3.1903e-10 PJ=0.00013246 perimeter=0.00013246 $X=4500 $Y=246525 $dt=18
D10 GNDRI VDDRI dipdnwmv AREA=1.3272e-10 PJ=5.464e-05 perimeter=5.464e-05 $X=44500 $Y=226395 $dt=18
R11 17 16 L=1.32e-06 W=1.2e-05 $[rdn3] $SUB=GNDOI $X=54270 $Y=203375 $dt=27
R12 16 18 L=1.32e-06 W=1.2e-05 $[rdn3] $SUB=GNDOI $X=56245 $Y=203375 $dt=27
R13 VDDOI 12 L=3.3e-06 W=4.4e-07 $[rdp3] $SUB=VDDOI $X=3990 $Y=178955 $dt=29
D14 VDDOI VDDOI p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=3990 $Y=177935 $dt=35
D15 12 VDDOI p_dp3 AREA=4.488e-13 PJ=2.48e-06 perimeter=2.48e-06 $X=3990 $Y=182255 $dt=35
R16 16 PAD L=4.5e-06 W=2.5e-06 $[rpp1] $X=52790 $Y=196775 $dt=40
.ends ICPC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: PSUBPADPC                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt PSUBPADPC PSUB GNDOI VDDOI VDD3I GNDI VDDRI GNDRI
** N=33 EP=7 FDC=149
X0 VDDOI 8 VDDOI jio_resg_pc $T=0 0 0 0 $X=4255 $Y=152520
X1 PSUB 9 VDDOI jio_resg_pc $T=60610 0 0 0 $X=64865 $Y=152520
X181 VDDOI PSUB 8 PSUB jio_base_ptrps_pc $T=0 0 0 0 $X=2500 $Y=149060
X320 PSUB GNDOI 12 13 jio_ne3isbg_pc $T=16420 75080 1 180 $X=6100 $Y=74005
X321 PSUB GNDOI 10 11 jio_ne3isbg_pc $T=16420 108880 1 180 $X=6100 $Y=107805
X322 PSUB GNDOI 20 21 jio_ne3isbg_pc $T=25420 75080 1 180 $X=15100 $Y=74005
X323 PSUB GNDOI 18 19 jio_ne3isbg_pc $T=25420 108880 1 180 $X=15100 $Y=107805
X324 PSUB GNDOI 16 17 jio_ne3isbg_pc $T=34420 75080 1 180 $X=24100 $Y=74005
X325 PSUB GNDOI 14 15 jio_ne3isbg_pc $T=34420 108880 1 180 $X=24100 $Y=107805
X326 PSUB GNDOI 24 25 jio_ne3isbg_pc $T=35580 75080 0 0 $X=34520 $Y=74005
X327 PSUB GNDOI 22 23 jio_ne3isbg_pc $T=35580 108880 0 0 $X=34520 $Y=107805
X328 PSUB GNDOI 32 33 jio_ne3isbg_pc $T=44580 75080 0 0 $X=43520 $Y=74005
X329 PSUB GNDOI 30 31 jio_ne3isbg_pc $T=44580 108880 0 0 $X=43520 $Y=107805
X330 PSUB GNDOI 28 29 jio_ne3isbg_pc $T=53580 75080 0 0 $X=52520 $Y=74005
X331 PSUB GNDOI 26 27 jio_ne3isbg_pc $T=53580 108880 0 0 $X=52520 $Y=107805
M0 13 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.89e-11 PD=6.001e-05 PS=6.126e-05 $X=7710 $Y=76905 $dt=5
M1 11 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.89e-11 PD=6.001e-05 PS=6.126e-05 $X=7710 $Y=110705 $dt=5
M2 PSUB 9 12 PSUB ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=15470 $Y=76905 $dt=5
M3 PSUB 9 10 PSUB ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=15470 $Y=110705 $dt=5
M4 21 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=16710 $Y=76905 $dt=5
M5 19 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=16710 $Y=110705 $dt=5
M6 PSUB 9 20 PSUB ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=24470 $Y=76905 $dt=5
M7 PSUB 9 18 PSUB ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=24470 $Y=110705 $dt=5
M8 17 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=25710 $Y=76905 $dt=5
M9 15 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=25710 $Y=110705 $dt=5
M10 PSUB 9 16 PSUB ne3i L=4e-07 W=3e-05 AD=3.39e-11 AS=1.5e-13 PD=3.226e-05 PS=6.001e-05 $X=33470 $Y=76905 $dt=5
M11 PSUB 9 14 PSUB ne3i L=4e-07 W=3e-05 AD=3.39e-11 AS=1.5e-13 PD=3.226e-05 PS=6.001e-05 $X=33470 $Y=110705 $dt=5
M12 24 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=3.39e-11 PD=6.001e-05 PS=3.226e-05 $X=36130 $Y=76905 $dt=5
M13 22 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=3.39e-11 PD=6.001e-05 PS=3.226e-05 $X=36130 $Y=110705 $dt=5
M14 PSUB 9 25 PSUB ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=43890 $Y=76905 $dt=5
M15 PSUB 9 23 PSUB ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=43890 $Y=110705 $dt=5
M16 32 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=45130 $Y=76905 $dt=5
M17 30 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=45130 $Y=110705 $dt=5
M18 PSUB 9 33 PSUB ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=52890 $Y=76905 $dt=5
M19 PSUB 9 31 PSUB ne3i L=4e-07 W=3e-05 AD=1.26e-11 AS=1.5e-13 PD=3.084e-05 PS=6.001e-05 $X=52890 $Y=110705 $dt=5
M20 28 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=54130 $Y=76905 $dt=5
M21 26 9 PSUB PSUB ne3i L=4e-07 W=3e-05 AD=1.5e-13 AS=1.26e-11 PD=6.001e-05 PS=3.084e-05 $X=54130 $Y=110705 $dt=5
M22 PSUB 9 29 PSUB ne3i L=4e-07 W=3e-05 AD=1.89e-11 AS=1.5e-13 PD=6.126e-05 PS=6.001e-05 $X=61890 $Y=76905 $dt=5
M23 PSUB 9 27 PSUB ne3i L=4e-07 W=3e-05 AD=1.89e-11 AS=1.5e-13 PD=6.126e-05 PS=6.001e-05 $X=61890 $Y=110705 $dt=5
D24 PSUB GNDOI ddnwmv AREA=4.69976e-09 PJ=0.00027464 perimeter=0.00027464 $X=2570 $Y=72575 $dt=16
D25 PSUB GNDOI dipdnwmv AREA=4.16648e-09 PJ=0.00025864 perimeter=0.00025864 $X=4570 $Y=74575 $dt=18
.ends PSUBPADPC

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_ddnw_2x100                                  *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_ddnw_2x100 A K
** N=2 EP=2 FDC=1
D0 A K ddnw AREA=3.89696e-10 PJ=0.000208648 perimeter=0.000208648 $X=-1370 $Y=4940 $dt=14
.ends ioh_ddnw_2x100

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_pmbsabhv_2x40_10                            *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_pmbsabhv_2x40_10 1 2 4 5
*.DEVICECLIMB
** N=8 EP=4 FDC=3
R0 4 2 L=5.1e-07 W=4e-05 $[rdp_io] $SUB=1 $X=-835 $Y=-20000 $dt=10
R1 2 5 L=5.1e-07 W=4e-05 $[rdp_io] $SUB=1 $X=330 $Y=-20000 $dt=10
D2 2 1 dphnw AREA=2.64e-11 PJ=1.32e-06 perimeter=1.32e-06 $X=-330 $Y=-20000 $dt=24
.ends ioh_pmbsabhv_2x40_10

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_pmbsabhv_2000                               *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_pmbsabhv_2000 Sub GSB D
** N=53 EP=3 FDC=126
X0 GSB D 6 7 ioh_pmbsabhv_2x40_10 $T=-50640 0 0 0 $X=-53780 $Y=-20960
X1 GSB D 4 5 ioh_pmbsabhv_2x40_10 $T=-46420 0 0 0 $X=-49560 $Y=-20960
X2 GSB D 10 11 ioh_pmbsabhv_2x40_10 $T=-42200 0 0 0 $X=-45340 $Y=-20960
X3 GSB D 8 9 ioh_pmbsabhv_2x40_10 $T=-37980 0 0 0 $X=-41120 $Y=-20960
X4 GSB D 14 15 ioh_pmbsabhv_2x40_10 $T=-33760 0 0 0 $X=-36900 $Y=-20960
X5 GSB D 12 13 ioh_pmbsabhv_2x40_10 $T=-29540 0 0 0 $X=-32680 $Y=-20960
X6 GSB D 18 19 ioh_pmbsabhv_2x40_10 $T=-25320 0 0 0 $X=-28460 $Y=-20960
X7 GSB D 16 17 ioh_pmbsabhv_2x40_10 $T=-21100 0 0 0 $X=-24240 $Y=-20960
X8 GSB D 22 23 ioh_pmbsabhv_2x40_10 $T=-16880 0 0 0 $X=-20020 $Y=-20960
X9 GSB D 20 21 ioh_pmbsabhv_2x40_10 $T=-12660 0 0 0 $X=-15800 $Y=-20960
X10 GSB D 24 25 ioh_pmbsabhv_2x40_10 $T=-8440 0 0 0 $X=-11580 $Y=-20960
X11 GSB D 28 29 ioh_pmbsabhv_2x40_10 $T=-4220 0 0 0 $X=-7360 $Y=-20960
X12 GSB D 26 27 ioh_pmbsabhv_2x40_10 $T=0 0 0 0 $X=-3140 $Y=-20960
X13 GSB D 32 33 ioh_pmbsabhv_2x40_10 $T=4220 0 0 0 $X=1080 $Y=-20960
X14 GSB D 30 31 ioh_pmbsabhv_2x40_10 $T=8440 0 0 0 $X=5300 $Y=-20960
X15 GSB D 36 37 ioh_pmbsabhv_2x40_10 $T=12660 0 0 0 $X=9520 $Y=-20960
X16 GSB D 34 35 ioh_pmbsabhv_2x40_10 $T=16880 0 0 0 $X=13740 $Y=-20960
X17 GSB D 40 41 ioh_pmbsabhv_2x40_10 $T=21100 0 0 0 $X=17960 $Y=-20960
X18 GSB D 38 39 ioh_pmbsabhv_2x40_10 $T=25320 0 0 0 $X=22180 $Y=-20960
X19 GSB D 44 45 ioh_pmbsabhv_2x40_10 $T=29540 0 0 0 $X=26400 $Y=-20960
X20 GSB D 42 43 ioh_pmbsabhv_2x40_10 $T=33760 0 0 0 $X=30620 $Y=-20960
X21 GSB D 48 49 ioh_pmbsabhv_2x40_10 $T=37980 0 0 0 $X=34840 $Y=-20960
X22 GSB D 46 47 ioh_pmbsabhv_2x40_10 $T=42200 0 0 0 $X=39060 $Y=-20960
X23 GSB D 50 51 ioh_pmbsabhv_2x40_10 $T=46420 0 0 0 $X=43280 $Y=-20960
X24 GSB D 52 53 ioh_pmbsabhv_2x40_10 $T=50640 0 0 0 $X=47500 $Y=-20960
M0 6 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=3.92e-11 PD=8.001e-05 PS=8.196e-05 $X=-52480 $Y=-20000 $dt=0
M1 GSB GSB 7 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-49800 $Y=-20000 $dt=0
M2 4 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-48260 $Y=-20000 $dt=0
M3 GSB GSB 5 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-45580 $Y=-20000 $dt=0
M4 10 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-44040 $Y=-20000 $dt=0
M5 GSB GSB 11 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-41360 $Y=-20000 $dt=0
M6 8 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-39820 $Y=-20000 $dt=0
M7 GSB GSB 9 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-37140 $Y=-20000 $dt=0
M8 14 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-35600 $Y=-20000 $dt=0
M9 GSB GSB 15 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-32920 $Y=-20000 $dt=0
M10 12 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-31380 $Y=-20000 $dt=0
M11 GSB GSB 13 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-28700 $Y=-20000 $dt=0
M12 18 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-27160 $Y=-20000 $dt=0
M13 GSB GSB 19 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-24480 $Y=-20000 $dt=0
M14 16 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-22940 $Y=-20000 $dt=0
M15 GSB GSB 17 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-20260 $Y=-20000 $dt=0
M16 22 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-18720 $Y=-20000 $dt=0
M17 GSB GSB 23 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-16040 $Y=-20000 $dt=0
M18 20 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-14500 $Y=-20000 $dt=0
M19 GSB GSB 21 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-11820 $Y=-20000 $dt=0
M20 24 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-10280 $Y=-20000 $dt=0
M21 GSB GSB 25 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-7600 $Y=-20000 $dt=0
M22 28 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-6060 $Y=-20000 $dt=0
M23 GSB GSB 29 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=-3380 $Y=-20000 $dt=0
M24 26 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=-1840 $Y=-20000 $dt=0
M25 GSB GSB 27 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=840 $Y=-20000 $dt=0
M26 32 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=2380 $Y=-20000 $dt=0
M27 GSB GSB 33 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=5060 $Y=-20000 $dt=0
M28 30 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=6600 $Y=-20000 $dt=0
M29 GSB GSB 31 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=9280 $Y=-20000 $dt=0
M30 36 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=10820 $Y=-20000 $dt=0
M31 GSB GSB 37 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=13500 $Y=-20000 $dt=0
M32 34 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=15040 $Y=-20000 $dt=0
M33 GSB GSB 35 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=17720 $Y=-20000 $dt=0
M34 40 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=19260 $Y=-20000 $dt=0
M35 GSB GSB 41 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=21940 $Y=-20000 $dt=0
M36 38 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=23480 $Y=-20000 $dt=0
M37 GSB GSB 39 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=26160 $Y=-20000 $dt=0
M38 44 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=27700 $Y=-20000 $dt=0
M39 GSB GSB 45 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=30380 $Y=-20000 $dt=0
M40 42 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=31920 $Y=-20000 $dt=0
M41 GSB GSB 43 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=34600 $Y=-20000 $dt=0
M42 48 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=36140 $Y=-20000 $dt=0
M43 GSB GSB 49 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=38820 $Y=-20000 $dt=0
M44 46 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=40360 $Y=-20000 $dt=0
M45 GSB GSB 47 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=43040 $Y=-20000 $dt=0
M46 50 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=44580 $Y=-20000 $dt=0
M47 GSB GSB 51 GSB pmb L=1e-06 W=4e-05 AD=1.08e-11 AS=2e-13 PD=4.054e-05 PS=8.001e-05 $X=47260 $Y=-20000 $dt=0
M48 52 GSB GSB GSB pmb L=1e-06 W=4e-05 AD=2e-13 AS=1.08e-11 PD=8.001e-05 PS=4.054e-05 $X=48800 $Y=-20000 $dt=0
M49 GSB GSB 53 GSB pmb L=1e-06 W=4e-05 AD=3.92e-11 AS=2e-13 PD=8.196e-05 PS=8.001e-05 $X=51480 $Y=-20000 $dt=0
D50 Sub GSB ddnw AREA=5.93551e-09 PJ=0.00033418 perimeter=0.00033418 $X=-57930 $Y=-24880 $dt=14
.ends ioh_pmbsabhv_2000

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_rnp1_20k                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_rnp1_20k T1 T2
** N=3 EP=2 FDC=1
R0 T2 T1 L=2.55e-05 W=4.2e-07 $[rnp1] $X=180 $Y=1220 $dt=39
.ends ioh_rnp1_20k

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_pe3sab_2x40_04                              *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_pe3sab_2x40_04 1 3 5 6
*.DEVICECLIMB
** N=9 EP=4 FDC=3
R0 5 3 L=4.3e-07 W=4e-05 $[rdp3] $SUB=1 $X=-755 $Y=-20000 $dt=30
R1 3 6 L=4.3e-07 W=4e-05 $[rdp3] $SUB=1 $X=330 $Y=-20000 $dt=30
D2 3 1 dp3 AREA=2.64e-11 PJ=1.32e-06 perimeter=1.32e-06 $X=-330 $Y=-20000 $dt=33
.ends ioh_pe3sab_2x40_04

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: ioh_pe3isabhv_2800gcr                           *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt ioh_pe3isabhv_2800gcr Sub SB D
** N=74 EP=3 FDC=177
X0 SB 4 ioh_rnp1_20k $T=51930 21460 0 90 $X=23990 $Y=21420
X1 SB D 7 8 ioh_pe3sab_2x40_04 $T=-51340 0 0 0 $X=-53990 $Y=-20960
X2 SB D 5 6 ioh_pe3sab_2x40_04 $T=-48320 0 0 0 $X=-50970 $Y=-20960
X3 SB D 13 14 ioh_pe3sab_2x40_04 $T=-45300 0 0 0 $X=-47950 $Y=-20960
X4 SB D 11 12 ioh_pe3sab_2x40_04 $T=-42280 0 0 0 $X=-44930 $Y=-20960
X5 SB D 9 10 ioh_pe3sab_2x40_04 $T=-39260 0 0 0 $X=-41910 $Y=-20960
X6 SB D 17 18 ioh_pe3sab_2x40_04 $T=-36240 0 0 0 $X=-38890 $Y=-20960
X7 SB D 15 16 ioh_pe3sab_2x40_04 $T=-33220 0 0 0 $X=-35870 $Y=-20960
X8 SB D 21 22 ioh_pe3sab_2x40_04 $T=-30200 0 0 0 $X=-32850 $Y=-20960
X9 SB D 19 20 ioh_pe3sab_2x40_04 $T=-27180 0 0 0 $X=-29830 $Y=-20960
X10 SB D 25 26 ioh_pe3sab_2x40_04 $T=-24160 0 0 0 $X=-26810 $Y=-20960
X11 SB D 23 24 ioh_pe3sab_2x40_04 $T=-21140 0 0 0 $X=-23790 $Y=-20960
X12 SB D 31 32 ioh_pe3sab_2x40_04 $T=-18120 0 0 0 $X=-20770 $Y=-20960
X13 SB D 29 30 ioh_pe3sab_2x40_04 $T=-15100 0 0 0 $X=-17750 $Y=-20960
X14 SB D 27 28 ioh_pe3sab_2x40_04 $T=-12080 0 0 0 $X=-14730 $Y=-20960
X15 SB D 35 36 ioh_pe3sab_2x40_04 $T=-9060 0 0 0 $X=-11710 $Y=-20960
X16 SB D 33 34 ioh_pe3sab_2x40_04 $T=-6040 0 0 0 $X=-8690 $Y=-20960
X17 SB D 39 40 ioh_pe3sab_2x40_04 $T=-3020 0 0 0 $X=-5670 $Y=-20960
X18 SB D 37 38 ioh_pe3sab_2x40_04 $T=0 0 0 0 $X=-2650 $Y=-20960
X19 SB D 45 46 ioh_pe3sab_2x40_04 $T=3020 0 0 0 $X=370 $Y=-20960
X20 SB D 43 44 ioh_pe3sab_2x40_04 $T=6040 0 0 0 $X=3390 $Y=-20960
X21 SB D 41 42 ioh_pe3sab_2x40_04 $T=9060 0 0 0 $X=6410 $Y=-20960
X22 SB D 49 50 ioh_pe3sab_2x40_04 $T=12080 0 0 0 $X=9430 $Y=-20960
X23 SB D 47 48 ioh_pe3sab_2x40_04 $T=15100 0 0 0 $X=12450 $Y=-20960
X24 SB D 53 54 ioh_pe3sab_2x40_04 $T=18120 0 0 0 $X=15470 $Y=-20960
X25 SB D 51 52 ioh_pe3sab_2x40_04 $T=21140 0 0 0 $X=18490 $Y=-20960
X26 SB D 59 60 ioh_pe3sab_2x40_04 $T=24160 0 0 0 $X=21510 $Y=-20960
X27 SB D 57 58 ioh_pe3sab_2x40_04 $T=27180 0 0 0 $X=24530 $Y=-20960
X28 SB D 55 56 ioh_pe3sab_2x40_04 $T=30200 0 0 0 $X=27550 $Y=-20960
X29 SB D 63 64 ioh_pe3sab_2x40_04 $T=33220 0 0 0 $X=30570 $Y=-20960
X30 SB D 61 62 ioh_pe3sab_2x40_04 $T=36240 0 0 0 $X=33590 $Y=-20960
X31 SB D 67 68 ioh_pe3sab_2x40_04 $T=39260 0 0 0 $X=36610 $Y=-20960
X32 SB D 65 66 ioh_pe3sab_2x40_04 $T=42280 0 0 0 $X=39630 $Y=-20960
X33 SB D 73 74 ioh_pe3sab_2x40_04 $T=45300 0 0 0 $X=42650 $Y=-20960
X34 SB D 71 72 ioh_pe3sab_2x40_04 $T=48320 0 0 0 $X=45670 $Y=-20960
X35 SB D 69 70 ioh_pe3sab_2x40_04 $T=51340 0 0 0 $X=48690 $Y=-20960
M0 7 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=3.64e-11 PD=8.001e-05 PS=8.182e-05 $X=-52500 $Y=-20000 $dt=6
M1 SB 4 8 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-50580 $Y=-20000 $dt=6
M2 5 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-49480 $Y=-20000 $dt=6
M3 SB 4 6 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-47560 $Y=-20000 $dt=6
M4 13 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-46460 $Y=-20000 $dt=6
M5 SB 4 14 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-44540 $Y=-20000 $dt=6
M6 11 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-43440 $Y=-20000 $dt=6
M7 SB 4 12 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-41520 $Y=-20000 $dt=6
M8 9 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-40420 $Y=-20000 $dt=6
M9 SB 4 10 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-38500 $Y=-20000 $dt=6
M10 17 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-37400 $Y=-20000 $dt=6
M11 SB 4 18 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-35480 $Y=-20000 $dt=6
M12 15 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-34380 $Y=-20000 $dt=6
M13 SB 4 16 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-32460 $Y=-20000 $dt=6
M14 21 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-31360 $Y=-20000 $dt=6
M15 SB 4 22 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-29440 $Y=-20000 $dt=6
M16 19 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-28340 $Y=-20000 $dt=6
M17 SB 4 20 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-26420 $Y=-20000 $dt=6
M18 25 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-25320 $Y=-20000 $dt=6
M19 SB 4 26 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-23400 $Y=-20000 $dt=6
M20 23 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-22300 $Y=-20000 $dt=6
M21 SB 4 24 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-20380 $Y=-20000 $dt=6
M22 31 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-19280 $Y=-20000 $dt=6
M23 SB 4 32 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-17360 $Y=-20000 $dt=6
M24 29 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-16260 $Y=-20000 $dt=6
M25 SB 4 30 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-14340 $Y=-20000 $dt=6
M26 27 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-13240 $Y=-20000 $dt=6
M27 SB 4 28 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-11320 $Y=-20000 $dt=6
M28 35 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-10220 $Y=-20000 $dt=6
M29 SB 4 36 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-8300 $Y=-20000 $dt=6
M30 33 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-7200 $Y=-20000 $dt=6
M31 SB 4 34 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-5280 $Y=-20000 $dt=6
M32 39 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-4180 $Y=-20000 $dt=6
M33 SB 4 40 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=-2260 $Y=-20000 $dt=6
M34 37 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=-1160 $Y=-20000 $dt=6
M35 SB 4 38 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=760 $Y=-20000 $dt=6
M36 45 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=1860 $Y=-20000 $dt=6
M37 SB 4 46 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=3780 $Y=-20000 $dt=6
M38 43 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=4880 $Y=-20000 $dt=6
M39 SB 4 44 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=6800 $Y=-20000 $dt=6
M40 41 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=7900 $Y=-20000 $dt=6
M41 SB 4 42 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=9820 $Y=-20000 $dt=6
M42 49 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=10920 $Y=-20000 $dt=6
M43 SB 4 50 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=12840 $Y=-20000 $dt=6
M44 47 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=13940 $Y=-20000 $dt=6
M45 SB 4 48 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=15860 $Y=-20000 $dt=6
M46 53 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=16960 $Y=-20000 $dt=6
M47 SB 4 54 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=18880 $Y=-20000 $dt=6
M48 51 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=19980 $Y=-20000 $dt=6
M49 SB 4 52 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=21900 $Y=-20000 $dt=6
M50 59 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=23000 $Y=-20000 $dt=6
M51 SB 4 60 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=24920 $Y=-20000 $dt=6
M52 57 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=26020 $Y=-20000 $dt=6
M53 SB 4 58 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=27940 $Y=-20000 $dt=6
M54 55 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=29040 $Y=-20000 $dt=6
M55 SB 4 56 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=30960 $Y=-20000 $dt=6
M56 63 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=32060 $Y=-20000 $dt=6
M57 SB 4 64 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=33980 $Y=-20000 $dt=6
M58 61 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=35080 $Y=-20000 $dt=6
M59 SB 4 62 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=37000 $Y=-20000 $dt=6
M60 67 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=38100 $Y=-20000 $dt=6
M61 SB 4 68 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=40020 $Y=-20000 $dt=6
M62 65 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=41120 $Y=-20000 $dt=6
M63 SB 4 66 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=43040 $Y=-20000 $dt=6
M64 73 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=44140 $Y=-20000 $dt=6
M65 SB 4 74 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=46060 $Y=-20000 $dt=6
M66 71 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=47160 $Y=-20000 $dt=6
M67 SB 4 72 SB pe3i L=4e-07 W=4e-05 AD=1.4e-11 AS=2e-13 PD=4.07e-05 PS=8.001e-05 $X=49080 $Y=-20000 $dt=6
M68 69 4 SB SB pe3i L=4e-07 W=4e-05 AD=2e-13 AS=1.4e-11 PD=8.001e-05 PS=4.07e-05 $X=50180 $Y=-20000 $dt=6
M69 SB 4 70 SB pe3i L=4e-07 W=4e-05 AD=3.64e-11 AS=2e-13 PD=8.182e-05 PS=8.001e-05 $X=52100 $Y=-20000 $dt=6
D70 Sub SB ddnw AREA=5.99691e-09 PJ=0.00033524 perimeter=0.00033524 $X=-57930 $Y=-24880 $dt=14
.ends ioh_pe3isabhv_2800gcr

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: HVDD4D2PK                                       *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt HVDD4D2PK PAD GND
** N=3 EP=2 FDC=304
X1 GND PAD ioh_ddnw_2x100 $T=75050 14500 0 0 $X=68510 $Y=14500
X2 GND PAD 3 ioh_pmbsabhv_2000 $T=113580 70000 0 90 $X=82560 $Y=7400
X3 GND 3 GND ioh_pe3isabhv_2800gcr $T=175340 70000 0 90 $X=143790 $Y=7400
.ends HVDD4D2PK

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: HVDD4DJ5PKFs                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt HVDD4DJ5PKFs GNDO PAD IGND
*.DEVICECLIMB
** N=10 EP=3 FDC=690
X98 GNDO PAD 5 ioh_dhpw_2x100 $T=86930 72000 0 0 $X=67600 $Y=9530
X99 GNDO 5 6 ioh_dhpw_2x100 $T=126250 72000 0 0 $X=106920 $Y=9530
X100 GNDO 6 IGND ioh_dhpw_2x100 $T=165570 72000 0 0 $X=146240 $Y=9530
X101 GNDO PAD 7 ioh_pmbsabhv_2000 $T=216580 72000 0 90 $X=185560 $Y=9400
X102 GNDO 7 8 ioh_pmbsabhv_2000 $T=277810 72000 0 90 $X=246790 $Y=9400
X103 GNDO 8 9 ioh_pmbsabhv_2000 $T=339040 72000 0 90 $X=308020 $Y=9400
X104 GNDO 9 10 ioh_pmbsabhv_2000 $T=400270 72000 0 90 $X=369250 $Y=9400
X105 GNDO 10 IGND ioh_pe3isabhv_2800gcr $T=462030 72000 0 90 $X=430480 $Y=9400
.ends HVDD4DJ5PKFs

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: aska_top_16ele_v2                               *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt aska_top_16ele_v2 GNDA GNDOHV PSUB VDDD GNDD GNDORA GNDOR VDDA VDDORA VDDOR
+ A1 A0 SPI_MOSI SPI_CLK SPI_CS resetn clk20k res_bias FB_RES GNDHV
+ VDDHV ELE<0> ELE<15> ELE<1> ELE<14> ELE<2> ELE<13> ELE<3> ELE<12> ELE<4>
+ ELE<5> ELE<6> ELE<7> ELE<8> ELE<9> ELE<10> ELE<11>
*.DEVICECLIMB
** N=168 EP=37 FDC=50123
X0 38 39 40 41 42 43 44 45 GNDHV VDDHV
+ ELE<0> 46 ELE<1> ELE<2> ELE<3> VDDD GNDD GNDOHV hbridge_4x $T=1565600 2124735 0 90 $X=593860 $Y=2131035
X1 47 48 49 50 51 52 53 54 GNDHV VDDHV
+ ELE<12> 46 ELE<13> ELE<14> ELE<15> VDDD GNDD GNDOHV hbridge_4x $T=586825 998890 0 270 $X=598085 $Y=590815
X2 55 56 57 58 59 60 61 62 GNDHV VDDHV
+ ELE<8> 46 ELE<9> ELE<10> ELE<11> VDDD GNDD GNDOHV hbridge_4x $T=1561820 585865 0 0 $X=1568120 $Y=597125
X3 63 64 65 66 67 68 69 70 GNDHV VDDHV
+ ELE<4> 46 ELE<5> ELE<6> ELE<7> VDDD GNDD GNDOHV hbridge_4x $T=1561820 1564640 0 0 $X=1568120 $Y=1575900
X15 GNDA GNDOHV 75 76 71 VDDA 77 78 79 80
+ 81 82 83 72 GNDHV VDDHV FB_RES 46 pulse_generator $T=444335 1138105 0 0 $X=461115 $Y=1157055
X16 GNDA 74 VDDA 75 73 71 72 GNDOHV bias $T=1221160 1595300 0 180 $X=511845 $Y=1372040
X17 VDDD GNDD 76 82 81 83 80 78 79 69
+ 42 40 38 84 67 85 65 59 63 61
+ 57 44 55 49 53 77 86 51 45 87
+ 47 60 62 66 39 41 88 89 90 43
+ 70 58 64 91 92 93 94 68 54 56
+ 95 96 52 97 98 50 48 99 100 101
+ 102 103 104 105 106 107 108 109 110 111
+ 112 113 114 115 116 117 118 119 120 121
+ 122 123 aska_dig $T=982185 1688130 0 0 $X=982265 $Y=1688130
X18 GNDA VDDA 74 75 88 GNDOHV por2 $T=946295 1926720 0 180 $X=557115 $Y=1679980
X496 GNDOHV ELE<0> GNDHV HVD4SJD1R5PKFs $T=603595 3134945 0 270 $X=603595 $Y=2683625
X497 GNDOHV ELE<15> GNDHV HVD4SJD1R5PKFs $T=821215 0 0 90 $X=676215 $Y=-320
X498 GNDOHV ELE<1> GNDHV HVD4SJD1R5PKFs $T=846165 3134945 0 270 $X=846165 $Y=2683625
X499 GNDOHV ELE<14> GNDHV HVD4SJD1R5PKFs $T=1063705 0 0 90 $X=918705 $Y=-320
X500 GNDOHV ELE<2> GNDHV HVD4SJD1R5PKFs $T=1088655 3134945 0 270 $X=1088655 $Y=2683625
X501 GNDOHV ELE<13> GNDHV HVD4SJD1R5PKFs $T=1306195 0 0 90 $X=1161195 $Y=-320
X502 GNDOHV ELE<3> GNDHV HVD4SJD1R5PKFs $T=1331145 3134945 0 270 $X=1331145 $Y=2683625
X503 GNDOHV ELE<12> GNDHV HVD4SJD1R5PKFs $T=1548765 0 0 90 $X=1403765 $Y=-320
X504 GNDOHV ELE<11> GNDHV HVD4SJD1R5PKFs $T=2564500 676255 1 180 $X=2113180 $Y=676255
X505 GNDOHV ELE<10> GNDHV HVD4SJD1R5PKFs $T=2564500 918745 1 180 $X=2113180 $Y=918745
X506 GNDOHV ELE<9> GNDHV HVD4SJD1R5PKFs $T=2564500 1161235 1 180 $X=2113180 $Y=1161235
X507 GNDOHV ELE<8> GNDHV HVD4SJD1R5PKFs $T=2564500 1403805 1 180 $X=2113180 $Y=1403805
X508 GNDOHV ELE<7> GNDHV HVD4SJD1R5PKFs $T=2564500 1655030 1 180 $X=2113180 $Y=1655030
X509 GNDOHV ELE<6> GNDHV HVD4SJD1R5PKFs $T=2564500 1897520 1 180 $X=2113180 $Y=1897520
X510 GNDOHV ELE<5> GNDHV HVD4SJD1R5PKFs $T=2564500 2140010 1 180 $X=2113180 $Y=2140010
X511 GNDOHV ELE<4> GNDHV HVD4SJD1R5PKFs $T=2564500 2380045 1 180 $X=2113180 $Y=2380045
X512 PSUB VDDORA FB_RES GNDORA VDDA GNDA VDDORA GNDORA APR00DPC $T=351000 351695 0 0 $X=350680 $Y=351695
X513 PSUB VDDORA FB_RES GNDORA VDDA GNDA VDDORA GNDORA APR00DPC $T=441000 351695 0 0 $X=440680 $Y=351695
X514 GNDOR PSUB GNDORA VDDD VDDOR GNDD GNDA VDDA VDDORA VDDOR
+ GNDOR VDDORA GNDORA PWRCUTDCPC $T=0 1217695 0 270 $X=71385 $Y=1147375
X515 GNDOHV PSUB GNDOR 124 125 126 GNDD VDDD VDDOR 127
+ 128 VDDOR GNDOR PWRCUTDCPC $T=471000 2778695 0 180 $X=400680 $Y=2517375
X516 GNDORA PSUB GNDOHV VDDA VDDORA GNDA 129 130 131 VDDORA
+ GNDORA 132 133 PWRCUTDCPC $T=511000 351695 0 0 $X=510680 $Y=423080
X517 PSUB VDDA VDDORA GNDORA GNDA res_bias 73 VDDORA GNDORA APR04DPC $T=261000 351695 0 0 $X=260680 $Y=351695
X543 GNDA VDDA VDDORA VDDORA GNDORA GNDORA PSUB GNDPADPC $T=0 817695 0 270 $X=0 $Y=747375
X544 GNDD VDDD VDDOR VDDOR GNDOR GNDOR PSUB GNDPADPC $T=0 2057695 0 270 $X=0 $Y=1987375
X545 PSUB VDDORA GNDORA VDDA GNDA VDDORA GNDORPADPC $T=0 927695 0 270 $X=0 $Y=857375
X546 PSUB VDDOR GNDOR VDDD GNDD VDDOR GNDORPADPC $T=0 2167695 0 270 $X=0 $Y=2097375
X547 VDDA GNDA VDDORA VDDORA GNDORA GNDORA PSUB VDDPADPC $T=0 1037695 0 270 $X=0 $Y=967375
X548 VDDD GNDD VDDOR VDDOR GNDOR GNDOR PSUB VDDPADPC $T=0 2277695 0 270 $X=0 $Y=2207375
X549 PSUB VDDORA GNDORA VDDA GNDA GNDORA VDDORPADPC $T=0 1147695 0 270 $X=0 $Y=1077375
X550 PSUB VDDOR GNDOR VDDD GNDD GNDOR VDDORPADPC $T=0 2387695 0 270 $X=0 $Y=2317375
X551 PSUB VDDOR VDDD GNDD GNDOR VDDOR GNDOR A1 95 134
+ GNDD ICPC $T=0 1287695 0 270 $X=0 $Y=1217375
X552 PSUB VDDOR VDDD GNDD GNDOR VDDOR GNDOR A0 98 135
+ GNDD ICPC $T=0 1397695 0 270 $X=0 $Y=1327375
X553 PSUB VDDOR VDDD GNDD GNDOR VDDOR GNDOR SPI_MOSI 91 136
+ GNDD ICPC $T=0 1507695 0 270 $X=0 $Y=1437375
X554 PSUB VDDOR VDDD GNDD GNDOR VDDOR GNDOR SPI_CLK 85 137
+ GNDD ICPC $T=0 1617695 0 270 $X=0 $Y=1547375
X555 PSUB VDDOR VDDD GNDD GNDOR VDDOR GNDOR SPI_CS 84 138
+ GNDD ICPC $T=0 1727695 0 270 $X=0 $Y=1657375
X556 PSUB VDDOR VDDD GNDD GNDOR VDDOR GNDOR resetn 87 139
+ GNDD ICPC $T=0 1837695 0 270 $X=0 $Y=1767375
X557 PSUB VDDOR VDDD GNDD GNDOR VDDOR GNDOR clk20k 86 140
+ GNDD ICPC $T=0 1947695 0 270 $X=0 $Y=1877375
X558 PSUB GNDOR VDDOR VDDD GNDD VDDOR GNDOR PSUBPADPC $T=401000 2778695 0 180 $X=330680 $Y=2517375
X559 GNDHV GNDOHV HVDD4D2PK $T=1798505 2890945 0 270 $X=1798505 $Y=2684545
X560 GNDOHV VDDHV GNDHV HVDD4DJ5PKFs $T=1571280 3171125 0 270 $X=1571280 $Y=2677805
D0 PSUB VDDD p_ddnwmv AREA=1.10287e-07 PJ=0.001398 perimeter=0.001398 $X=980615 $Y=1686560 $dt=17
.ends aska_top_16ele_v2

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: aska_top_16ele_v2_TOP                           *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt aska_top_16ele_v2_TOP A0 A1 ELE<0> ELE<10> ELE<11> ELE<12> ELE<13> ELE<14> ELE<15> ELE<1>
+ ELE<2> ELE<3> ELE<4> ELE<5> ELE<6> ELE<7> ELE<8> ELE<9> FB_RES GNDA
+ GNDD GNDHV GNDOR GNDORA PSUB SPI_CLK SPI_CS SPI_MOSI VDDA VDDD
+ VDDHV VDDOR VDDORA clk20k res_bias resetn
** N=36 EP=36 FDC=50124
X0 GNDA GNDA PSUB VDDD GNDD GNDORA GNDOR VDDA VDDORA VDDOR
+ A1 A0 SPI_MOSI SPI_CLK SPI_CS resetn clk20k res_bias FB_RES GNDHV
+ VDDHV ELE<0> ELE<15> ELE<1> ELE<14> ELE<2> ELE<13> ELE<3> ELE<12> ELE<4>
+ ELE<5> ELE<6> ELE<7> ELE<8> ELE<9> ELE<10> ELE<11> aska_top_16ele_v2 $T=18700 26385 0 0 $X=18700 $Y=26065
R0 PSUB GNDA 5 $[s_res] $X=615415 $Y=26380 $dt=11
.ends aska_top_16ele_v2_TOP
